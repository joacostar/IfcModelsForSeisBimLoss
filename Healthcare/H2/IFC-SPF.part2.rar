Properties of the parts of a building model (IFC4), part 4 of 6

# IfcPipeFitting: M_Te - Genérica:Norma (61)
Name (M_Te - Genérica:Norma:...) | Centro a etiqueta de extremo (m) = Centro a extremo (m) | Radio exterior de unión (m) | Elevation from Level (m) | Diámetro exterior de unión (m) | Diámetro nominal (m) = Maximum Size (m) = Minimum Size (m) | Radio nominal (m) | Size | Tamaño de marca (m) | Volume (m3) | System Name = Group | Overall Size
910336 | 0.0237875 | 0.0110875 | 3.45 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø-0.019ø | 0.00887 | 0.0000239249 | Suministro hidrónico 3 | 19 mmø-19 mmø-19 mmø
910493 | 0.0237875 | 0.0110875 | 3.45 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø-0.019ø | 0.00887 | 0.0000239249 | Suministro hidrónico 3 | 19 mmø-19 mmø-19 mmø
910556 | 0.0237875 | 0.0110875 | 3.48 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø-0.019ø | 0.00887 | 0.0000239249 | Suministro hidrónico 1 | 19 mmø-19 mmø-19 mmø
911786 | 0.0237875 | 0.0110875 | 3.45 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø-0.019ø | 0.00887 | 0.0000239249 | Suministro hidrónico 3 | 19 mmø-19 mmø-19 mmø
912764 | 0.0202875 | 0.0075875 | 3.45 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø-0.012ø | 0.00607 | 0.00000984248 | Suministro hidrónico 3 | 12 mmø-12 mmø-12 mmø
912768 | 0.0237875 | 0.0110875 | 3.45 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø-0.019ø | 0.00887 | 0.0000239249 | Suministro hidrónico 3 | 19 mmø-19 mmø-19 mmø
913097 | 0.0237875 | 0.0110875 | 3.45 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø-0.019ø | 0.00887 | 0.0000239249 | Suministro hidrónico 3 | 19 mmø-19 mmø-19 mmø
913107 | 0.0202875 | 0.0075875 | 3.45 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø-0.012ø | 0.00607 | 0.00000984248 | Suministro hidrónico 3 | 12 mmø-12 mmø-12 mmø
913922 | 0.0237875 | 0.0110875 | 3.48 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø-0.019ø | 0.00887 | 0.0000239249 | Suministro hidrónico 1 | 19 mmø-19 mmø-19 mmø
916330 | 0.0237875 | 0.0110875 | 3.48 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø-0.019ø | 0.00887 | 0.0000239249 | Suministro hidrónico 1 | 19 mmø-19 mmø-19 mmø
916459 | 0.0202875 | 0.0075875 | 3.48 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø-0.012ø | 0.00607 | 0.00000984248 | Suministro hidrónico 1 | 12 mmø-12 mmø-12 mmø
916463 | 0.0237875 | 0.0110875 | 3.48 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø-0.019ø | 0.00887 | 0.0000239249 | Suministro hidrónico 1 | 19 mmø-19 mmø-19 mmø
916490 | 0.0202875 | 0.0075875 | 3.48 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø-0.012ø | 0.00607 | 0.00000984248 | Suministro hidrónico 1 | 12 mmø-12 mmø-12 mmø
916494 | 0.0237875 | 0.0110875 | 3.48 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø-0.019ø | 0.00887 | 0.0000239249 | Suministro hidrónico 1 | 19 mmø-19 mmø-19 mmø
916752 | 0.0237875 | 0.0110875 | 3.45 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø-0.019ø | 0.00887 | 0.0000239249 | Suministro hidrónico 3 | 19 mmø-19 mmø-19 mmø
917429 | 0.0237875 | 0.0110875 | 3.48 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø-0.019ø | 0.00887 | 0.0000239249 | Suministro hidrónico 1 | 19 mmø-19 mmø-19 mmø
921280 | 0.0269875 | 0.0142875 | 3.45 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø-0.025ø | 0.01143 | 0.0000441423 | Suministro hidrónico 3 | 25 mmø-25 mmø-25 mmø
921330 | 0.0269875 | 0.0142875 | 3.48 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø-0.025ø | 0.01143 | 0.0000441423 | Suministro hidrónico 1 | 25 mmø-25 mmø-25 mmø
923957 | 0.0237875 | 0.0110875 | 3.48 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø-0.019ø | 0.00887 | 0.0000239249 | Suministro hidrónico 4 | 19 mmø-19 mmø-19 mmø
924030 | 0.0237875 | 0.0110875 | 3.48 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø-0.019ø | 0.00887 | 0.0000239249 | Suministro hidrónico 4 | 19 mmø-19 mmø-19 mmø
924727 | 0.0202875 | 0.0075875 | 3.48 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø-0.012ø | 0.00607 | 0.00000984248 | Suministro hidrónico 1 | 12 mmø-12 mmø-12 mmø
925079 | 0.0237875 | 0.0110875 | 3.48 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø-0.019ø | 0.00887 | 0.0000239249 | Suministro hidrónico 4 | 19 mmø-19 mmø-19 mmø
936594 | 0.0202875 | 0.0075875 | 3.45 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø-0.012ø | 0.00607 | 0.00000984248 | Suministro hidrónico 3 | 12 mmø-12 mmø-12 mmø
936615 | 0.0202875 | 0.0075875 | 3.48 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø-0.012ø | 0.00607 | 0.00000984248 | Suministro hidrónico 1 | 12 mmø-12 mmø-12 mmø
936646 | 0.0202875 | 0.0075875 | 3.45 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø-0.012ø | 0.00607 | 0.00000984248 | Suministro hidrónico 3 | 12 mmø-12 mmø-12 mmø
936667 | 0.0202875 | 0.0075875 | 3.48 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø-0.012ø | 0.00607 | 0.00000984248 | Suministro hidrónico 1 | 12 mmø-12 mmø-12 mmø
936824 | 0.0202875 | 0.0075875 | 3.45 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø-0.012ø | 0.00607 | 0.00000984248 | Suministro hidrónico 3 | 12 mmø-12 mmø-12 mmø
936845 | 0.0202875 | 0.0075875 | 3.48 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø-0.012ø | 0.00607 | 0.00000984248 | Suministro hidrónico 1 | 12 mmø-12 mmø-12 mmø
936870 | 0.0202875 | 0.0075875 | 3.48 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø-0.012ø | 0.00607 | 0.00000984248 | Suministro hidrónico 1 | 12 mmø-12 mmø-12 mmø
936891 | 0.0202875 | 0.0075875 | 3.45 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø-0.012ø | 0.00607 | 0.00000984248 | Suministro hidrónico 3 | 12 mmø-12 mmø-12 mmø
937077 | 0.0237875 | 0.0110875 | 3.45 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø-0.019ø | 0.00887 | 0.0000239249 | Suministro hidrónico 3 | 19 mmø-19 mmø-19 mmø
937117 | 0.0237875 | 0.0110875 | 3.48 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø-0.019ø | 0.00887 | 0.0000239249 | Suministro hidrónico 1 | 19 mmø-19 mmø-19 mmø
937205 | 0.0237875 | 0.0110875 | 3.48 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø-0.019ø | 0.00887 | 0.0000239249 | Suministro hidrónico 1 | 19 mmø-19 mmø-19 mmø
937244 | 0.0237875 | 0.0110875 | 3.45 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø-0.019ø | 0.00887 | 0.0000239249 | Suministro hidrónico 3 | 19 mmø-19 mmø-19 mmø
937452 | 0.0202875 | 0.0075875 | 3.45 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø-0.012ø | 0.00607 | 0.00000984248 | Suministro hidrónico 3 | 12 mmø-12 mmø-12 mmø
937475 | 0.0202875 | 0.0075875 | 3.48 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø-0.012ø | 0.00607 | 0.00000984248 | Suministro hidrónico 1 | 12 mmø-12 mmø-12 mmø
937498 | 0.0202875 | 0.0075875 | 3.45 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø-0.012ø | 0.00607 | 0.00000984248 | Suministro hidrónico 3 | 12 mmø-12 mmø-12 mmø
937521 | 0.0202875 | 0.0075875 | 3.48 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø-0.012ø | 0.00607 | 0.00000984248 | Suministro hidrónico 1 | 12 mmø-12 mmø-12 mmø
937775 | 0.0202875 | 0.0075875 | 3.45 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø-0.012ø | 0.00607 | 0.00000984248 | Suministro hidrónico 3 | 12 mmø-12 mmø-12 mmø
937783 | 0.0202875 | 0.0075875 | 3.48 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø-0.012ø | 0.00607 | 0.00000984248 | Suministro hidrónico 1 | 12 mmø-12 mmø-12 mmø
937879 | 0.0202875 | 0.0075875 | 3.48 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø-0.012ø | 0.00607 | 0.00000984248 | Suministro hidrónico 1 | 12 mmø-12 mmø-12 mmø
937887 | 0.0202875 | 0.0075875 | 3.48 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø-0.012ø | 0.00607 | 0.00000984248 | Suministro hidrónico 1 | 12 mmø-12 mmø-12 mmø
937895 | 0.0202875 | 0.0075875 | 3.45 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø-0.012ø | 0.00607 | 0.00000984248 | Suministro hidrónico 3 | 12 mmø-12 mmø-12 mmø
937903 | 0.0202875 | 0.0075875 | 3.45 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø-0.012ø | 0.00607 | 0.00000984248 | Suministro hidrónico 3 | 12 mmø-12 mmø-12 mmø
937911 | 0.0202875 | 0.0075875 | 3.48 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø-0.012ø | 0.00607 | 0.00000984248 | Suministro hidrónico 1 | 12 mmø-12 mmø-12 mmø
937919 | 0.0202875 | 0.0075875 | 3.45 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø-0.012ø | 0.00607 | 0.00000984248 | Suministro hidrónico 3 | 12 mmø-12 mmø-12 mmø
938045 | 0.0202875 | 0.0075875 | 3.48 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø-0.012ø | 0.00607 | 0.00000984248 | Suministro hidrónico 1 | 12 mmø-12 mmø-12 mmø
938053 | 0.0202875 | 0.0075875 | 3.48 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø-0.012ø | 0.00607 | 0.00000984248 | Suministro hidrónico 1 | 12 mmø-12 mmø-12 mmø
938061 | 0.0202875 | 0.0075875 | 3.45 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø-0.012ø | 0.00607 | 0.00000984248 | Suministro hidrónico 3 | 12 mmø-12 mmø-12 mmø
938069 | 0.0202875 | 0.0075875 | 3.45 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø-0.012ø | 0.00607 | 0.00000984248 | Suministro hidrónico 3 | 12 mmø-12 mmø-12 mmø
938278 | 0.0237875 | 0.0110875 | 3.45 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø-0.019ø | 0.00887 | 0.0000239249 | Suministro hidrónico 3 | 19 mmø-19 mmø-19 mmø
938292 | 0.0237875 | 0.0110875 | 3.48 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø-0.019ø | 0.00887 | 0.0000239249 | Suministro hidrónico 1 | 19 mmø-19 mmø-19 mmø
940581 | 0.0237875 | 0.0110875 | 2.2 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø-0.019ø | 0.00887 | 0.0000239249 | Suministro hidrónico 1 | 19 mmø-19 mmø-19 mmø
940587 | 0.0237875 | 0.0110875 | 2.2 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø-0.019ø | 0.00887 | 0.0000239249 | Suministro hidrónico 1 | 19 mmø-19 mmø-19 mmø
940636 | 0.0237875 | 0.0110875 | 2.2 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø-0.019ø | 0.00887 | 0.0000239249 | Suministro hidrónico 3 | 19 mmø-19 mmø-19 mmø
940640 | 0.0237875 | 0.0110875 | 2.2 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø-0.019ø | 0.00887 | 0.0000239249 | Suministro hidrónico 3 | 19 mmø-19 mmø-19 mmø
945693 | 0.0269875 | 0.0142875 | 2.44 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø-0.025ø | 0.01143 | 0.0000441423 | Suministro hidrónico 1 | 25 mmø-25 mmø-25 mmø
953290 | 0.0269875 | 0.0142875 | 2.44 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø-0.025ø | 0.01143 | 0.0000441423 | Suministro hidrónico 3 | 25 mmø-25 mmø-25 mmø
953427 | 0.0269875 | 0.0142875 | 2.2 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø-0.025ø | 0.01143 | 0.0000441423 | Suministro hidrónico 1 | 25 mmø-25 mmø-25 mmø
953464 | 0.0269875 | 0.0142875 | 2.2 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø-0.025ø | 0.01143 | 0.0000441423 | Suministro hidrónico 3 | 25 mmø-25 mmø-25 mmø

# IfcPipeFitting: M_Te - Soldada - Genérica:Norma (2)
In: Nivel 1
Type - Material: <Unnamed>
Type - Other - Category: Pipe Fittings; Family Name: M_Te - Soldada - Genérica; Nombre de tabla de consulta: M_Tee - Welded - Generic
Type - Constraints - Default Elevation: 0 m
Type - Identity Data - OmniClass Number: 23.60.30.11.14; OmniClass Title: Pipework Fittings; Type Name: Norma
Type - Mechanical - Loss Method: K Coefficient from Table; Connection Type: Generic; K Coefficient Table: Tee
Classification: D2022.0 (FEMAP58); Group: Suministro hidrónico 4
Pset_EnvironmentalImpactIndicators - Reference: M_Te - Soldada - Genérica:Norma; sets with these values: 2
Other - Type: Norma; Ángulo 1: 90 deg; Centro a etiqueta de extremo: 0.048 m; Family: M_Te - Soldada - Genérica; Family and Type: M_Te - Soldada - Genérica: Norma; Radio exterior de unión: 0.0211 m; Type Id: 553594
Constraints - Level: Nivel 1; Elevation from Level: 3.48 m
Dimensions - Ángulo: 90 deg; Centro a extremo: 0.048 m; Diámetro exterior de unión: 0.0422 m; Diámetro nominal: 0.032 m; Maximum Size: 0.032 m; Minimum Size: 0.032 m; Radio nominal: 0.016 m; Size: 0.032ø-0.032ø-0.032ø; Tamaño de marca: 0.01688 m; Volume: 0.000176351 m3
Graphics - Use Annotation Scale: yes
Mechanical - System Type: Suministro hidrónico; System Classification: Hydronic Supply; System Name: Suministro hidrónico 4
Phasing - Phase Created: Nueva construcción
Insulation - Insulation Thickness: 0 m; Overall Size: 32 mmø-32 mmø-32 mmø
AboveGround - AboveGround: yes
Name (M_Te - Soldada - Genérica:Norma:...)
922113
955101

# IfcPipeFitting: M_Transición - Genérica:Norma (92)
In: Nivel 1
Type - Material: <Unnamed>
Type - Other - Category: Pipe Fittings; Family Name: M_Transición - Genérica; Nombre de tabla de consulta: M_Pipe Fitting - Generic
Type - Constraints - Default Elevation: 0 m
Type - Identity Data - OmniClass Number: 23.60.30.11.14; OmniClass Title: Pipework Fittings; Type Name: Norma
Type - Mechanical - Loss Method: K Coefficient from Table; Connection Type: Generic; K Coefficient Table: Reducer/Coupling/Union/Increaser
Pset_EnvironmentalImpactIndicators - Reference: M_Transición - Genérica:Norma; sets with these values: 2
Other - Type: Norma; Desfase de altura: 32.8084 m; Desfase de anchura: 32.8084 m; Family: M_Transición - Genérica; Family and Type: M_Transición - Genérica: Norma; Type Id: 194831; Visibilidad 1: no
Constraints - Level: Nivel 1
Graphics - Use Annotation Scale: yes
Phasing - Phase Created: Nueva construcción
Insulation - Insulation Thickness: 0 m
AboveGround - AboveGround: yes
Name (M_Transición - Genérica:Norma:...) | Classification | Diámetro exterior de unión máx. 12 (m) | Radio exterior de unión 1 (m) | Radio exterior de unión 2 (m) | Visibilidad 2 | Visibilidad 3 | Elevation from Level (m) | Area (m2) | Diámetro exterior de unión 1 (m) | Diámetro exterior de unión 2 (m) | Diámetro nominal 1 (m) | Diámetro nominal 2 (m) | Longitud (m) | Maximum Size (m) | Minimum Size (m) | OffsetHeight = OffsetWidth | Radio nominal 1 (m) | Radio nominal 2 (m) | Size | Tamaño de marca 1 (m) | Tamaño de marca 2 (m) | Volume (m3) | System Type | System Classification | System Name = Group | Overall Size
909963 | D2022.0 (FEMAP58) | 0.022175 | 0.0075875 | 0.0110875 | no | yes | 3.48 | 0.00050693 | 0.015175 | 0.022175 | 0.012 | 0.019 | 0.00554375 | 0.019 | 0.012 | 6 | 0.006 | 0.0095 | 0.019ø-0.012ø | 0.00607 | 0.00887 | 0.0000015253 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 1 | 19 mmø-12 mmø
910056 | D2022.0 (FEMAP58) | 0.022175 | 0.0075875 | 0.0110875 | no | yes | 3.48 | 0.00050693 | 0.015175 | 0.022175 | 0.012 | 0.019 | 0.00554375 | 0.019 | 0.012 | 6 | 0.006 | 0.0095 | 0.019ø-0.012ø | 0.00607 | 0.00887 | 0.0000015253 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 1 | 19 mmø-12 mmø
910246 | D2022.0 (FEMAP58) | 0.022175 | 0.0075875 | 0.0110875 | no | yes | 3.45 | 0.00050693 | 0.015175 | 0.022175 | 0.012 | 0.019 | 0.00554375 | 0.019 | 0.012 | 6 | 0.006 | 0.0095 | 0.019ø-0.012ø | 0.00607 | 0.00887 | 0.0000015253 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 3 | 19 mmø-12 mmø
910518 | D2022.0 (FEMAP58) | 0.022175 | 0.0110875 | 0.0075875 | yes | no | 3.45 | 0.00050693 | 0.022175 | 0.015175 | 0.019 | 0.012 | 0.00554375 | 0.019 | 0.012 | 9.5 | 0.0095 | 0.006 | 0.019ø-0.012ø | 0.00887 | 0.00607 | 0.00000151283 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 3 | 19 mmø-12 mmø
910520 | D2022.0 (FEMAP58) | 0.022175 | 0.0110875 | 0.0075875 | yes | no | 3.45 | 0.00050693 | 0.022175 | 0.015175 | 0.019 | 0.012 | 0.00554375 | 0.019 | 0.012 | 9.5 | 0.0095 | 0.006 | 0.019ø-0.012ø | 0.00887 | 0.00607 | 0.00000151283 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 3 | 19 mmø-12 mmø
910526 | D2022.0 (FEMAP58) | 0.022175 | 0.0110875 | 0.0075875 | yes | no | 3.45 | 0.00050693 | 0.022175 | 0.015175 | 0.019 | 0.012 | 0.00554375 | 0.019 | 0.012 | 9.5 | 0.0095 | 0.006 | 0.019ø-0.012ø | 0.00887 | 0.00607 | 0.00000151283 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 3 | 19 mmø-12 mmø
910528 | D2022.0 (FEMAP58) | 0.022175 | 0.0110875 | 0.0075875 | yes | no | 3.45 | 0.00050693 | 0.022175 | 0.015175 | 0.019 | 0.012 | 0.00554375 | 0.019 | 0.012 | 9.5 | 0.0095 | 0.006 | 0.019ø-0.012ø | 0.00887 | 0.00607 | 0.00000151283 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 3 | 19 mmø-12 mmø
910530 | D2022.0 (FEMAP58) | 0.022175 | 0.0110875 | 0.0075875 | yes | no | 3.45 | 0.00050693 | 0.022175 | 0.015175 | 0.019 | 0.012 | 0.00554375 | 0.019 | 0.012 | 9.5 | 0.0095 | 0.006 | 0.019ø-0.012ø | 0.00887 | 0.00607 | 0.00000151283 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 3 | 19 mmø-12 mmø
911794 | D2022.0 (FEMAP58) | 0.022175 | 0.0110875 | 0.0075875 | yes | no | 3.45 | 0.00050693 | 0.022175 | 0.015175 | 0.019 | 0.012 | 0.00554375 | 0.019 | 0.012 | 9.5 | 0.0095 | 0.006 | 0.019ø-0.012ø | 0.00887 | 0.00607 | 0.00000151283 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 3 | 19 mmø-12 mmø
912776 | D2022.0 (FEMAP58) | 0.022175 | 0.0110875 | 0.0075875 | yes | no | 3.45 | 0.00050693 | 0.022175 | 0.015175 | 0.019 | 0.012 | 0.00554375 | 0.019 | 0.012 | 9.5 | 0.0095 | 0.006 | 0.019ø-0.012ø | 0.00887 | 0.00607 | 0.00000151283 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 3 | 19 mmø-12 mmø
913105 | D2022.0 (FEMAP58) | 0.022175 | 0.0110875 | 0.0075875 | yes | no | 3.45 | 0.00050693 | 0.022175 | 0.015175 | 0.019 | 0.012 | 0.00554375 | 0.019 | 0.012 | 9.5 | 0.0095 | 0.006 | 0.019ø-0.012ø | 0.00887 | 0.00607 | 0.00000151283 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 3 | 19 mmø-12 mmø
913930 | D2022.0 (FEMAP58) | 0.022175 | 0.0110875 | 0.0075875 | yes | no | 3.48 | 0.00050693 | 0.022175 | 0.015175 | 0.019 | 0.012 | 0.00554375 | 0.019 | 0.012 | 9.5 | 0.0095 | 0.006 | 0.019ø-0.012ø | 0.00887 | 0.00607 | 0.00000151283 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 1 | 19 mmø-12 mmø
915536 | D2022.0 (FEMAP58) | 0.034925 | 0.0110875 | 0.0174625 | no | yes | 3.48 | 0.00128656 | 0.022175 | 0.034925 | 0.019 | 0.032 | 0.00873125 | 0.032 | 0.019 | 9.5 | 0.0095 | 0.016 | 0.032ø-0.019ø | 0.00887 | 0.01397 | 0.00000564554 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 4 | 32 mmø-19 mmø
916338 | D2022.0 (FEMAP58) | 0.022175 | 0.0110875 | 0.0075875 | yes | no | 3.48 | 0.00050693 | 0.022175 | 0.015175 | 0.019 | 0.012 | 0.00554375 | 0.019 | 0.012 | 9.5 | 0.0095 | 0.006 | 0.019ø-0.012ø | 0.00887 | 0.00607 | 0.00000151283 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 1 | 19 mmø-12 mmø
916471 | D2022.0 (FEMAP58) | 0.022175 | 0.0110875 | 0.0075875 | yes | no | 3.48 | 0.00050693 | 0.022175 | 0.015175 | 0.019 | 0.012 | 0.00554375 | 0.019 | 0.012 | 9.5 | 0.0095 | 0.006 | 0.019ø-0.012ø | 0.00887 | 0.00607 | 0.00000151283 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 1 | 19 mmø-12 mmø
916502 | D2022.0 (FEMAP58) | 0.022175 | 0.0110875 | 0.0075875 | yes | no | 3.48 | 0.00050693 | 0.022175 | 0.015175 | 0.019 | 0.012 | 0.00554375 | 0.019 | 0.012 | 9.5 | 0.0095 | 0.006 | 0.019ø-0.012ø | 0.00887 | 0.00607 | 0.00000151283 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 1 | 19 mmø-12 mmø
916760 | D2022.0 (FEMAP58) | 0.022175 | 0.0110875 | 0.0075875 | yes | no | 3.45 | 0.00050693 | 0.022175 | 0.015175 | 0.019 | 0.012 | 0.00554375 | 0.019 | 0.012 | 9.5 | 0.0095 | 0.006 | 0.019ø-0.012ø | 0.00887 | 0.00607 | 0.00000151283 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 3 | 19 mmø-12 mmø
917109 | D2022.0 (FEMAP58) | 0.028575 | 0.0142875 | 0.0110875 | yes | no | 3.45 | 0.000922013 | 0.028575 | 0.022175 | 0.025 | 0.019 | 0.00714375 | 0.025 | 0.019 | 12.5 | 0.0125 | 0.0095 | 0.025ø-0.019ø | 0.01143 | 0.00887 | 0.00000361579 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 3 | 25 mmø-19 mmø
917437 | D2022.0 (FEMAP58) | 0.022175 | 0.0110875 | 0.0075875 | yes | no | 3.48 | 0.00050693 | 0.022175 | 0.015175 | 0.019 | 0.012 | 0.00554375 | 0.019 | 0.012 | 9.5 | 0.0095 | 0.006 | 0.019ø-0.012ø | 0.00887 | 0.00607 | 0.00000151283 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 1 | 19 mmø-12 mmø
917485 | D2022.0 (FEMAP58) | 0.022175 | 0.0075875 | 0.0110875 | no | yes | 3.45 | 0.00050693 | 0.015175 | 0.022175 | 0.012 | 0.019 | 0.00554375 | 0.019 | 0.012 | 6 | 0.006 | 0.0095 | 0.019ø-0.012ø | 0.00607 | 0.00887 | 0.0000015253 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 3 | 19 mmø-12 mmø
917562 | D2022.0 (FEMAP58) | 0.028575 | 0.0142875 | 0.0110875 | yes | no | 3.48 | 0.000922013 | 0.028575 | 0.022175 | 0.025 | 0.019 | 0.00714375 | 0.025 | 0.019 | 12.5 | 0.0125 | 0.0095 | 0.025ø-0.019ø | 0.01143 | 0.00887 | 0.00000361579 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 1 | 25 mmø-19 mmø
920399 | D2022.0 (FEMAP58) | 0.015875 | 0.0075875 | 0.0079375 | no | yes | 4.40116 | 0.000328879 | 0.015175 | 0.015875 | 0.012 | 0.015 | 0.00396875 | 0.015 | 0.012 | 6 | 0.006 | 0.0075 | 0.015ø-0.012ø | 0.00607 | 0.00635 | 7.43554e-07 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 4 | 15 mmø-12 mmø
920402 | D2022.0 (FEMAP58) | 0.015875 | 0.0075875 | 0.0079375 | no | yes | 4.33322 | 0.000328879 | 0.015175 | 0.015875 | 0.012 | 0.015 | 0.00396875 | 0.015 | 0.012 | 6 | 0.006 | 0.0075 | 0.015ø-0.012ø | 0.00607 | 0.00635 | 7.43554e-07 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 4 | 15 mmø-12 mmø
920490 | D2022.0 (FEMAP58) | 0.015875 | 0.0075875 | 0.0079375 | no | yes | 4.40186 | 0.000328879 | 0.015175 | 0.015875 | 0.012 | 0.015 | 0.00396875 | 0.015 | 0.012 | 6 | 0.006 | 0.0075 | 0.015ø-0.012ø | 0.00607 | 0.00635 | 7.43554e-07 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 4 | 15 mmø-12 mmø
920492 | D2022.0 (FEMAP58) | 0.015875 | 0.0075875 | 0.0079375 | no | yes | 4.33392 | 0.000328879 | 0.015175 | 0.015875 | 0.012 | 0.015 | 0.00396875 | 0.015 | 0.012 | 6 | 0.006 | 0.0075 | 0.015ø-0.012ø | 0.00607 | 0.00635 | 7.43554e-07 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 4 | 15 mmø-12 mmø
920654 | D2022.0 (FEMAP58) | 0.015875 | 0.0075875 | 0.0079375 | no | yes | 4.35603 | 0.000328879 | 0.015175 | 0.015875 | 0.012 | 0.015 | 0.00396875 | 0.015 | 0.012 | 6 | 0.006 | 0.0075 | 0.015ø-0.012ø | 0.00607 | 0.00635 | 7.43554e-07 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 4 | 15 mmø-12 mmø
920656 | D2022.0 (FEMAP58) | 0.015875 | 0.0075875 | 0.0079375 | no | yes | 4.42397 | 0.000328879 | 0.015175 | 0.015875 | 0.012 | 0.015 | 0.00396875 | 0.015 | 0.012 | 6 | 0.006 | 0.0075 | 0.015ø-0.012ø | 0.00607 | 0.00635 | 7.43554e-07 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 4 | 15 mmø-12 mmø
920786 | D2022.0 (FEMAP58) | 0.015875 | 0.0075875 | 0.0079375 | no | yes | 4.35603 | 0.000328879 | 0.015175 | 0.015875 | 0.012 | 0.015 | 0.00396875 | 0.015 | 0.012 | 6 | 0.006 | 0.0075 | 0.015ø-0.012ø | 0.00607 | 0.00635 | 7.43554e-07 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 4 | 15 mmø-12 mmø
920788 | D2022.0 (FEMAP58) | 0.015875 | 0.0075875 | 0.0079375 | no | yes | 4.42397 | 0.000328879 | 0.015175 | 0.015875 | 0.012 | 0.015 | 0.00396875 | 0.015 | 0.012 | 6 | 0.006 | 0.0075 | 0.015ø-0.012ø | 0.00607 | 0.00635 | 7.43554e-07 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 4 | 15 mmø-12 mmø
920960 | D2022.0 (FEMAP58) | 0.015875 | 0.0075875 | 0.0079375 | no | yes | 4.33603 | 0.000328879 | 0.015175 | 0.015875 | 0.012 | 0.015 | 0.00396875 | 0.015 | 0.012 | 6 | 0.006 | 0.0075 | 0.015ø-0.012ø | 0.00607 | 0.00635 | 7.43554e-07 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 4 | 15 mmø-12 mmø
920962 | D2022.0 (FEMAP58) | 0.015875 | 0.0075875 | 0.0079375 | no | yes | 4.40397 | 0.000328879 | 0.015175 | 0.015875 | 0.012 | 0.015 | 0.00396875 | 0.015 | 0.012 | 6 | 0.006 | 0.0075 | 0.015ø-0.012ø | 0.00607 | 0.00635 | 7.43554e-07 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 4 | 15 mmø-12 mmø
922121 | D2022.0 (FEMAP58) | 0.034925 | 0.0174625 | 0.0142875 | yes | no | 3.48 | 0.00146184 | 0.034925 | 0.028575 | 0.032 | 0.025 | 0.00873125 | 0.032 | 0.025 | 16 | 0.016 | 0.0125 | 0.032ø-0.025ø | 0.01397 | 0.01143 | 0.00000690657 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 4 | 32 mmø-25 mmø
923434 | D2022.0 (FEMAP58) | 0.028575 | 0.0142875 | 0.0110875 | yes | no | 3.48 | 0.000922013 | 0.028575 | 0.022175 | 0.025 | 0.019 | 0.00714375 | 0.025 | 0.019 | 12.5 | 0.0125 | 0.0095 | 0.025ø-0.019ø | 0.01143 | 0.00887 | 0.00000361579 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 1 | 25 mmø-19 mmø
923524 | D2022.0 (FEMAP58) | 0.028575 | 0.0142875 | 0.0110875 | yes | no | 3.45 | 0.000922013 | 0.028575 | 0.022175 | 0.025 | 0.019 | 0.00714375 | 0.025 | 0.019 | 12.5 | 0.0125 | 0.0095 | 0.025ø-0.019ø | 0.01143 | 0.00887 | 0.00000361579 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 3 | 25 mmø-19 mmø
923908 | D2022.0 (FEMAP58) | 0.022175 | 0.0075875 | 0.0110875 | no | yes | 3.48 | 0.00050693 | 0.015175 | 0.022175 | 0.012 | 0.019 | 0.00554375 | 0.019 | 0.012 | 6 | 0.006 | 0.0095 | 0.019ø-0.012ø | 0.00607 | 0.00887 | 0.0000015253 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 4 | 19 mmø-12 mmø
923910 | D2022.0 (FEMAP58) | 0.034925 | 0.0110875 | 0.0174625 | no | yes | 3.48 | 0.00128656 | 0.022175 | 0.034925 | 0.019 | 0.032 | 0.00873125 | 0.032 | 0.019 | 9.5 | 0.0095 | 0.016 | 0.032ø-0.019ø | 0.00887 | 0.01397 | 0.00000564554 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 4 | 32 mmø-19 mmø
923965 | D2022.0 (FEMAP58) | 0.022175 | 0.0110875 | 0.0075875 | yes | no | 3.48 | 0.00050693 | 0.022175 | 0.015175 | 0.019 | 0.012 | 0.00554375 | 0.019 | 0.012 | 9.5 | 0.0095 | 0.006 | 0.019ø-0.012ø | 0.00887 | 0.00607 | 0.00000151283 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 4 | 19 mmø-12 mmø
924024 | D2022.0 (FEMAP58) | 0.022175 | 0.0110875 | 0.0075875 | yes | no | 3.48 | 0.00050693 | 0.022175 | 0.015175 | 0.019 | 0.012 | 0.00554375 | 0.019 | 0.012 | 9.5 | 0.0095 | 0.006 | 0.019ø-0.012ø | 0.00887 | 0.00607 | 0.00000151283 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 4 | 19 mmø-12 mmø
924038 | D2022.0 (FEMAP58) | 0.022175 | 0.0110875 | 0.0075875 | yes | no | 3.48 | 0.00050693 | 0.022175 | 0.015175 | 0.019 | 0.012 | 0.00554375 | 0.019 | 0.012 | 9.5 | 0.0095 | 0.006 | 0.019ø-0.012ø | 0.00887 | 0.00607 | 0.00000151283 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 4 | 19 mmø-12 mmø
924731 | D2022.0 (FEMAP58) | 0.022175 | 0.0075875 | 0.0110875 | no | yes | 3.48 | 0.00050693 | 0.015175 | 0.022175 | 0.012 | 0.019 | 0.00554375 | 0.019 | 0.012 | 6 | 0.006 | 0.0095 | 0.019ø-0.012ø | 0.00607 | 0.00887 | 0.0000015253 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 1 | 19 mmø-12 mmø
925081 | D2022.0 (FEMAP58) | 0.022175 | 0.0110875 | 0.0075875 | yes | no | 3.48 | 0.00050693 | 0.022175 | 0.015175 | 0.019 | 0.012 | 0.00554375 | 0.019 | 0.012 | 9.5 | 0.0095 | 0.006 | 0.019ø-0.012ø | 0.00887 | 0.00607 | 0.00000151283 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 4 | 19 mmø-12 mmø
925083 | D2022.0 (FEMAP58) | 0.022175 | 0.0110875 | 0.0075875 | yes | no | 3.48 | 0.00050693 | 0.022175 | 0.015175 | 0.019 | 0.012 | 0.00554375 | 0.019 | 0.012 | 9.5 | 0.0095 | 0.006 | 0.019ø-0.012ø | 0.00887 | 0.00607 | 0.00000151283 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 4 | 19 mmø-12 mmø
933210 | D2022.0 (FEMAP58) | 0.028575 | 0.0142875 | 0.0110875 | yes | no | 1.6 | 0.000929877 | 0.028575 | 0.022175 | 0.0254 | 0.019 | 0.00714375 | 0.0254 | 0.019 | 12.7 | 0.0127 | 0.0095 | 0.025ø-0.019ø | 0.01143 | 0.00887 | 0.00000361579 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 1 | 25 mmø-19 mmø
933212 | D2022.0 (FEMAP58) | 0.028575 | 0.0142875 | 0.0110875 | yes | no | 1.6 | 0.000929877 | 0.028575 | 0.022175 | 0.0254 | 0.019 | 0.00714375 | 0.0254 | 0.019 | 12.7 | 0.0127 | 0.0095 | 0.025ø-0.019ø | 0.01143 | 0.00887 | 0.00000361579 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 1 | 25 mmø-19 mmø
933266 | D2022.0 (FEMAP58) | 0.028575 | 0.0142875 | 0.0110875 | yes | no | 1.73157 | 0.000929877 | 0.028575 | 0.022175 | 0.0254 | 0.019 | 0.00714375 | 0.0254 | 0.019 | 12.7 | 0.0127 | 0.0095 | 0.025ø-0.019ø | 0.01143 | 0.00887 | 0.00000361579 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 3 | 25 mmø-19 mmø
933268 | D2022.0 (FEMAP58) | 0.028575 | 0.0142875 | 0.0110875 | yes | no | 1.73157 | 0.000929877 | 0.028575 | 0.022175 | 0.0254 | 0.019 | 0.00714375 | 0.0254 | 0.019 | 12.7 | 0.0127 | 0.0095 | 0.025ø-0.019ø | 0.01143 | 0.00887 | 0.00000361579 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 3 | 25 mmø-19 mmø
933870 | D2022.0 (FEMAP58) | 0.028575 | 0.0142875 | 0.0110875 | yes | no | 1.72 | 0.000929877 | 0.028575 | 0.022175 | 0.0254 | 0.019 | 0.00714375 | 0.0254 | 0.019 | 12.7 | 0.0127 | 0.0095 | 0.025ø-0.019ø | 0.01143 | 0.00887 | 0.00000361579 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 3 | 25 mmø-19 mmø
933872 | D2022.0 (FEMAP58) | 0.028575 | 0.0142875 | 0.0110875 | yes | no | 1.72 | 0.000929877 | 0.028575 | 0.022175 | 0.0254 | 0.019 | 0.00714375 | 0.0254 | 0.019 | 12.7 | 0.0127 | 0.0095 | 0.025ø-0.019ø | 0.01143 | 0.00887 | 0.00000361579 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 3 | 25 mmø-19 mmø
933895 | D2022.0 (FEMAP58) | 0.028575 | 0.0142875 | 0.0110875 | yes | no | 1.6 | 0.000929877 | 0.028575 | 0.022175 | 0.0254 | 0.019 | 0.00714375 | 0.0254 | 0.019 | 12.7 | 0.0127 | 0.0095 | 0.025ø-0.019ø | 0.01143 | 0.00887 | 0.00000361579 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 1 | 25 mmø-19 mmø
933897 | D2022.0 (FEMAP58) | 0.028575 | 0.0142875 | 0.0110875 | yes | no | 1.6 | 0.000929877 | 0.028575 | 0.022175 | 0.0254 | 0.019 | 0.00714375 | 0.0254 | 0.019 | 12.7 | 0.0127 | 0.0095 | 0.025ø-0.019ø | 0.01143 | 0.00887 | 0.00000361579 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 1 | 25 mmø-19 mmø
937085 | D2022.0 (FEMAP58) | 0.022175 | 0.0110875 | 0.0075875 | yes | no | 3.45 | 0.00050693 | 0.022175 | 0.015175 | 0.019 | 0.012 | 0.00554375 | 0.019 | 0.012 | 9.5 | 0.0095 | 0.006 | 0.019ø-0.012ø | 0.00887 | 0.00607 | 0.00000151283 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 3 | 19 mmø-12 mmø
937125 | D2022.0 (FEMAP58) | 0.022175 | 0.0110875 | 0.0075875 | yes | no | 3.48 | 0.00050693 | 0.022175 | 0.015175 | 0.019 | 0.012 | 0.00554375 | 0.019 | 0.012 | 9.5 | 0.0095 | 0.006 | 0.019ø-0.012ø | 0.00887 | 0.00607 | 0.00000151283 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 1 | 19 mmø-12 mmø
937213 | D2022.0 (FEMAP58) | 0.022175 | 0.0110875 | 0.0075875 | yes | no | 3.48 | 0.00050693 | 0.022175 | 0.015175 | 0.019 | 0.012 | 0.00554375 | 0.019 | 0.012 | 9.5 | 0.0095 | 0.006 | 0.019ø-0.012ø | 0.00887 | 0.00607 | 0.00000151283 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 1 | 19 mmø-12 mmø
937252 | D2022.0 (FEMAP58) | 0.022175 | 0.0110875 | 0.0075875 | yes | no | 3.45 | 0.00050693 | 0.022175 | 0.015175 | 0.019 | 0.012 | 0.00554375 | 0.019 | 0.012 | 9.5 | 0.0095 | 0.006 | 0.019ø-0.012ø | 0.00887 | 0.00607 | 0.00000151283 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 3 | 19 mmø-12 mmø
938286 | D2022.0 (FEMAP58) | 0.022175 | 0.0110875 | 0.0075875 | yes | no | 3.45 | 0.00050693 | 0.022175 | 0.015175 | 0.019 | 0.012 | 0.00554375 | 0.019 | 0.012 | 9.5 | 0.0095 | 0.006 | 0.019ø-0.012ø | 0.00887 | 0.00607 | 0.00000151283 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 3 | 19 mmø-12 mmø
938300 | D2022.0 (FEMAP58) | 0.022175 | 0.0110875 | 0.0075875 | yes | no | 3.48 | 0.00050693 | 0.022175 | 0.015175 | 0.019 | 0.012 | 0.00554375 | 0.019 | 0.012 | 9.5 | 0.0095 | 0.006 | 0.019ø-0.012ø | 0.00887 | 0.00607 | 0.00000151283 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 1 | 19 mmø-12 mmø
940508 | D2022.0 (FEMAP58) | 0.034925 | 0.0174625 | 0.0110875 | yes | no | 1.64139 | 0.00128656 | 0.034925 | 0.022175 | 0.032 | 0.019 | 0.00873125 | 0.032 | 0.019 | 16 | 0.016 | 0.0095 | 0.032ø-0.019ø | 0.01397 | 0.00887 | 0.0000056532 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 1 | 32 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
940510 | D2022.0 (FEMAP58) | 0.034925 | 0.0174625 | 0.0110875 | yes | no | 1.64139 | 0.00128656 | 0.034925 | 0.022175 | 0.032 | 0.019 | 0.00873125 | 0.032 | 0.019 | 16 | 0.016 | 0.0095 | 0.032ø-0.019ø | 0.01397 | 0.00887 | 0.0000056532 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 1 | 32 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
940512 | D2022.0 (FEMAP58) | 0.034925 | 0.0174625 | 0.0110875 | yes | no | 1.64139 | 0.00128656 | 0.034925 | 0.022175 | 0.032 | 0.019 | 0.00873125 | 0.032 | 0.019 | 16 | 0.016 | 0.0095 | 0.032ø-0.019ø | 0.01397 | 0.00887 | 0.0000056532 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 1 | 32 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
940514 | D2022.0 (FEMAP58) | 0.034925 | 0.0174625 | 0.0110875 | yes | no | 1.64139 | 0.00128656 | 0.034925 | 0.022175 | 0.032 | 0.019 | 0.00873125 | 0.032 | 0.019 | 16 | 0.016 | 0.0095 | 0.032ø-0.019ø | 0.01397 | 0.00887 | 0.0000056532 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 1 | 32 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
940516 | D2022.0 (FEMAP58) | 0.034925 | 0.0174625 | 0.0110875 | yes | no | 1.64139 | 0.00128656 | 0.034925 | 0.022175 | 0.032 | 0.019 | 0.00873125 | 0.032 | 0.019 | 16 | 0.016 | 0.0095 | 0.032ø-0.019ø | 0.01397 | 0.00887 | 0.0000056532 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 1 | 32 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
940518 | D2022.0 (FEMAP58) | 0.034925 | 0.0174625 | 0.0110875 | yes | no | 1.64139 | 0.00128656 | 0.034925 | 0.022175 | 0.032 | 0.019 | 0.00873125 | 0.032 | 0.019 | 16 | 0.016 | 0.0095 | 0.032ø-0.019ø | 0.01397 | 0.00887 | 0.0000056532 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 1 | 32 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
940520 | D2022.0 (FEMAP58) | 0.034925 | 0.0174625 | 0.0110875 | yes | no | 1.64139 | 0.00128656 | 0.034925 | 0.022175 | 0.032 | 0.019 | 0.00873125 | 0.032 | 0.019 | 16 | 0.016 | 0.0095 | 0.032ø-0.019ø | 0.01397 | 0.00887 | 0.0000056532 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 1 | 32 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
940522 | D2022.0 (FEMAP58) | 0.034925 | 0.0174625 | 0.0110875 | yes | no | 1.64139 | 0.00128656 | 0.034925 | 0.022175 | 0.032 | 0.019 | 0.00873125 | 0.032 | 0.019 | 16 | 0.016 | 0.0095 | 0.032ø-0.019ø | 0.01397 | 0.00887 | 0.0000056532 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 1 | 32 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
940524 | D2022.0 (FEMAP58) | 0.034925 | 0.0174625 | 0.0110875 | yes | no | 1.64139 | 0.00128656 | 0.034925 | 0.022175 | 0.032 | 0.019 | 0.00873125 | 0.032 | 0.019 | 16 | 0.016 | 0.0095 | 0.032ø-0.019ø | 0.01397 | 0.00887 | 0.0000056532 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 1 | 32 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
940526 | D2022.0 (FEMAP58) | 0.034925 | 0.0174625 | 0.0110875 | yes | no | 1.64139 | 0.00128656 | 0.034925 | 0.022175 | 0.032 | 0.019 | 0.00873125 | 0.032 | 0.019 | 16 | 0.016 | 0.0095 | 0.032ø-0.019ø | 0.01397 | 0.00887 | 0.0000056532 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 1 | 32 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
940528 | D2022.0 (FEMAP58) | 0.034925 | 0.0174625 | 0.0110875 | yes | no | 1.64139 | 0.00128656 | 0.034925 | 0.022175 | 0.032 | 0.019 | 0.00873125 | 0.032 | 0.019 | 16 | 0.016 | 0.0095 | 0.032ø-0.019ø | 0.01397 | 0.00887 | 0.0000056532 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 1 | 32 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
940530 | D2022.0 (FEMAP58) | 0.034925 | 0.0174625 | 0.0110875 | yes | no | 1.64139 | 0.00128656 | 0.034925 | 0.022175 | 0.032 | 0.019 | 0.00873125 | 0.032 | 0.019 | 16 | 0.016 | 0.0095 | 0.032ø-0.019ø | 0.01397 | 0.00887 | 0.0000056532 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 1 | 32 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
940532 | D2022.0 (FEMAP58) | 0.034925 | 0.0174625 | 0.0110875 | yes | no | 1.64139 | 0.00128656 | 0.034925 | 0.022175 | 0.032 | 0.019 | 0.00873125 | 0.032 | 0.019 | 16 | 0.016 | 0.0095 | 0.032ø-0.019ø | 0.01397 | 0.00887 | 0.0000056532 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 1 | 32 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
940534 | D2022.0 (FEMAP58) | 0.034925 | 0.0174625 | 0.0110875 | yes | no | 1.64139 | 0.00128656 | 0.034925 | 0.022175 | 0.032 | 0.019 | 0.00873125 | 0.032 | 0.019 | 16 | 0.016 | 0.0095 | 0.032ø-0.019ø | 0.01397 | 0.00887 | 0.0000056532 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 1 | 32 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
940536 | D2022.0 (FEMAP58) | 0.034925 | 0.0174625 | 0.0110875 | yes | no | 1.64139 | 0.00128656 | 0.034925 | 0.022175 | 0.032 | 0.019 | 0.00873125 | 0.032 | 0.019 | 16 | 0.016 | 0.0095 | 0.032ø-0.019ø | 0.01397 | 0.00887 | 0.0000056532 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 3 | 32 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
940538 | D2022.0 (FEMAP58) | 0.034925 | 0.0174625 | 0.0110875 | yes | no | 1.64139 | 0.00128656 | 0.034925 | 0.022175 | 0.032 | 0.019 | 0.00873125 | 0.032 | 0.019 | 16 | 0.016 | 0.0095 | 0.032ø-0.019ø | 0.01397 | 0.00887 | 0.0000056532 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 3 | 32 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
940540 | D2022.0 (FEMAP58) | 0.034925 | 0.0174625 | 0.0110875 | yes | no | 1.64139 | 0.00128656 | 0.034925 | 0.022175 | 0.032 | 0.019 | 0.00873125 | 0.032 | 0.019 | 16 | 0.016 | 0.0095 | 0.032ø-0.019ø | 0.01397 | 0.00887 | 0.0000056532 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 3 | 32 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
940542 | D2022.0 (FEMAP58) | 0.034925 | 0.0174625 | 0.0110875 | yes | no | 1.64139 | 0.00128656 | 0.034925 | 0.022175 | 0.032 | 0.019 | 0.00873125 | 0.032 | 0.019 | 16 | 0.016 | 0.0095 | 0.032ø-0.019ø | 0.01397 | 0.00887 | 0.0000056532 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 3 | 32 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
940544 | D2022.0 (FEMAP58) | 0.034925 | 0.0174625 | 0.0110875 | yes | no | 1.64139 | 0.00128656 | 0.034925 | 0.022175 | 0.032 | 0.019 | 0.00873125 | 0.032 | 0.019 | 16 | 0.016 | 0.0095 | 0.032ø-0.019ø | 0.01397 | 0.00887 | 0.0000056532 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 3 | 32 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
940546 | D2022.0 (FEMAP58) | 0.034925 | 0.0174625 | 0.0110875 | yes | no | 1.64139 | 0.00128656 | 0.034925 | 0.022175 | 0.032 | 0.019 | 0.00873125 | 0.032 | 0.019 | 16 | 0.016 | 0.0095 | 0.032ø-0.019ø | 0.01397 | 0.00887 | 0.0000056532 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 3 | 32 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
940548 | D2022.0 (FEMAP58) | 0.034925 | 0.0174625 | 0.0110875 | yes | no | 1.64139 | 0.00128656 | 0.034925 | 0.022175 | 0.032 | 0.019 | 0.00873125 | 0.032 | 0.019 | 16 | 0.016 | 0.0095 | 0.032ø-0.019ø | 0.01397 | 0.00887 | 0.0000056532 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 3 | 32 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
940550 | D2022.0 (FEMAP58) | 0.034925 | 0.0174625 | 0.0110875 | yes | no | 1.64139 | 0.00128656 | 0.034925 | 0.022175 | 0.032 | 0.019 | 0.00873125 | 0.032 | 0.019 | 16 | 0.016 | 0.0095 | 0.032ø-0.019ø | 0.01397 | 0.00887 | 0.0000056532 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 3 | 32 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
940552 | D2022.0 (FEMAP58) | 0.034925 | 0.0174625 | 0.0110875 | yes | no | 1.64139 | 0.00128656 | 0.034925 | 0.022175 | 0.032 | 0.019 | 0.00873125 | 0.032 | 0.019 | 16 | 0.016 | 0.0095 | 0.032ø-0.019ø | 0.01397 | 0.00887 | 0.0000056532 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 3 | 32 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
940554 | D2022.0 (FEMAP58) | 0.034925 | 0.0174625 | 0.0110875 | yes | no | 1.64139 | 0.00128656 | 0.034925 | 0.022175 | 0.032 | 0.019 | 0.00873125 | 0.032 | 0.019 | 16 | 0.016 | 0.0095 | 0.032ø-0.019ø | 0.01397 | 0.00887 | 0.0000056532 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 3 | 32 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
940556 | D2022.0 (FEMAP58) | 0.034925 | 0.0174625 | 0.0110875 | yes | no | 1.64139 | 0.00128656 | 0.034925 | 0.022175 | 0.032 | 0.019 | 0.00873125 | 0.032 | 0.019 | 16 | 0.016 | 0.0095 | 0.032ø-0.019ø | 0.01397 | 0.00887 | 0.0000056532 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 3 | 32 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
940558 | D2022.0 (FEMAP58) | 0.034925 | 0.0174625 | 0.0110875 | yes | no | 1.64139 | 0.00128656 | 0.034925 | 0.022175 | 0.032 | 0.019 | 0.00873125 | 0.032 | 0.019 | 16 | 0.016 | 0.0095 | 0.032ø-0.019ø | 0.01397 | 0.00887 | 0.0000056532 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 3 | 32 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
940560 | D2022.0 (FEMAP58) | 0.034925 | 0.0174625 | 0.0110875 | yes | no | 1.64139 | 0.00128656 | 0.034925 | 0.022175 | 0.032 | 0.019 | 0.00873125 | 0.032 | 0.019 | 16 | 0.016 | 0.0095 | 0.032ø-0.019ø | 0.01397 | 0.00887 | 0.0000056532 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 3 | 32 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
940562 | D2022.0 (FEMAP58) | 0.034925 | 0.0174625 | 0.0110875 | yes | no | 1.64139 | 0.00128656 | 0.034925 | 0.022175 | 0.032 | 0.019 | 0.00873125 | 0.032 | 0.019 | 16 | 0.016 | 0.0095 | 0.032ø-0.019ø | 0.01397 | 0.00887 | 0.0000056532 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 3 | 32 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
953152 | D2021.0 (FEMAP58) | 0.053975 | 0.0269875 | 0.0142875 | yes | no | 0.2548 | 0.00293885 | 0.053975 | 0.028575 | 0.0508 | 0.025 | 0.0134938 | 0.0508 | 0.025 | 25.4 | 0.0254 | 0.0125 | 0.051ø-0.025ø | 0.02159 | 0.01143 | 0.0000185809 | Agua fría doméstica | Domestic Cold Water | Agua fría doméstica 1 | 51 mmø-25 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
953431 | D2022.0 (FEMAP58) | 0.028575 | 0.0142875 | 0.0110875 | yes | no | 2.2 | 0.000922013 | 0.028575 | 0.022175 | 0.025 | 0.019 | 0.00714375 | 0.025 | 0.019 | 12.5 | 0.0125 | 0.0095 | 0.025ø-0.019ø | 0.01143 | 0.00887 | 0.00000361579 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 1 | 25 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
953434 | D2022.0 (FEMAP58) | 0.028575 | 0.0142875 | 0.0110875 | yes | no | 2.2 | 0.000922013 | 0.028575 | 0.022175 | 0.025 | 0.019 | 0.00714375 | 0.025 | 0.019 | 12.5 | 0.0125 | 0.0095 | 0.025ø-0.019ø | 0.01143 | 0.00887 | 0.00000361579 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 1 | 25 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
953468 | D2022.0 (FEMAP58) | 0.028575 | 0.0142875 | 0.0110875 | yes | no | 2.2 | 0.000922013 | 0.028575 | 0.022175 | 0.025 | 0.019 | 0.00714375 | 0.025 | 0.019 | 12.5 | 0.0125 | 0.0095 | 0.025ø-0.019ø | 0.01143 | 0.00887 | 0.00000361579 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 3 | 25 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
953470 | D2022.0 (FEMAP58) | 0.028575 | 0.0142875 | 0.0110875 | yes | no | 2.2 | 0.000922013 | 0.028575 | 0.022175 | 0.025 | 0.019 | 0.00714375 | 0.025 | 0.019 | 12.5 | 0.0125 | 0.0095 | 0.025ø-0.019ø | 0.01143 | 0.00887 | 0.00000361579 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 3 | 25 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
954125 | D2022.0 (FEMAP58) | 0.015875 | 0.0075875 | 0.0079375 | no | yes | 4.33938 | 0.000328879 | 0.015175 | 0.015875 | 0.012 | 0.015 | 0.00396875 | 0.015 | 0.012 | 6 | 0.006 | 0.0075 | 0.015ø-0.012ø | 0.00607 | 0.00635 | 7.43554e-07 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 4 | 15 mmø-12 mmø
954127 | D2022.0 (FEMAP58) | 0.015875 | 0.0075875 | 0.0079375 | no | yes | 4.27144 | 0.000328879 | 0.015175 | 0.015875 | 0.012 | 0.015 | 0.00396875 | 0.015 | 0.012 | 6 | 0.006 | 0.0075 | 0.015ø-0.012ø | 0.00607 | 0.00635 | 7.43554e-07 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 4 | 15 mmø-12 mmø
955109 | D2022.0 (FEMAP58) | 0.034925 | 0.0174625 | 0.0110875 | yes | no | 3.48 | 0.00128656 | 0.034925 | 0.022175 | 0.032 | 0.019 | 0.00873125 | 0.032 | 0.019 | 16 | 0.016 | 0.0095 | 0.032ø-0.019ø | 0.01397 | 0.00887 | 0.0000056532 | Suministro hidrónico | Hydronic Supply | Suministro hidrónico 4 | 32 mmø-19 mmø

# IfcPipeSegment: Pipe Types:Aire Dental (54)
Type - Other - Category: Pipes; Family Name: Pipe Types
Type - Identity Data - Type Name: Aire Dental
Classification: D2022 (FEMAP58); Material: Cobre; Group: Suministro hidrónico 4
Pset_EnvironmentalImpactIndicators - Reference: Pipe Types:Aire Dental; sets with these values: 2
Other - Family: Pipe Types; Family and Type: Pipe Types: Aire Dental; Type: Aire Dental; Type Id: 915083
Constraints - Horizontal Justification: Center; Vertical Justification: Middle
Dimensions - Wall Thickness: 0 m
Mechanical - Material: Cobre; Pipe Segment: Cobre - A; Schedule/Type: A; System Type: Suministro hidrónico; Connection Type: Generic; Roughness: 0.00000254 m; System Classification: Hydronic Supply; System Name: Suministro hidrónico 4
Mechanical - Flow - Additional Flow: 0 dm3/s; Flow: 0 dm3/s; Flow State: Laminar; Friction Factor: 0; Pressure Drop: 0 Pa; Reynolds Number: 0; Velocity: 0 m/s; Velocity Pressure: 0 Pa; Friction: 0
Phasing - Phase Created: Nueva construcción
Insulation - Insulation Thickness: 0 m
AboveGround - AboveGround: yes
Name (Pipe Types:Aire Dental:...) | In | InvertElevation (m) = Invert Elevation (m) | Pset_FlowSegmentDiameter, Diameter (m) = Inside Diameter (m) = Outside Diameter (m) = Mechanical, Diameter (m) | Qto_PipeSegmentBaseQuantities, Length (m) = Dimensions, Length (m) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) = Area (m2) | Reference Level | Slope | End Middle Elevation (m) | Lower End Bottom Elevation (m) = Lower End Invert Elevation (m) = Lower End Bottom of Insulation Elevation (m) | Lower End Centerline Elevation (m) | Lower End Obvert Elevation (m) = Lower End Top Elevation (m) = Lower End Top of Insulation Elevation (m) | Middle Elevation (m) = Start Middle Elevation (m) | Upper End Bottom Elevation (m) = Upper End Invert Elevation (m) = Upper End Bottom of Insulation Elevation (m) | Upper End Centerline Elevation (m) | Upper End Obvert Elevation (m) = Upper End Top Elevation (m) = Upper End Top of Insulation Elevation (m) | Size | Relative Roughness | Section | Overall Size
915098 | Nivel 1 | 3.474 | 0.012 | 2.03121 | 0.00011308 | 0.0765747 | Nivel 1 | 0 | 3.48 | 3.474 | 3.48 | 3.486 | 3.48 | 3.474 | 3.48 | 3.486 | 0.012ø | 0.000211667 | 203 | 12 mmø
915115 | Nivel 1 | 3.474 | 0.012 | 1.11413 | 0.00011308 | 0.0420016 | Nivel 1 | 0 | 3.48 | 3.474 | 3.48 | 3.486 | 3.48 | 3.474 | 3.48 | 3.486 | 0.012ø | 0.000211667 | 204 | 12 mmø
915123 | Nivel 2 | 3.474 | 0.012 | 0.450295 | 0.00011308 | 0.0169757 | Nivel 2 | 0 | -0.77 | -0.776 | -0.77 | -0.764 | -0.77 | -0.776 | -0.77 | -0.764 | 0.012ø | 0.000211667 | 204 | 12 mmø
915133 | Nivel 2 | 3.474 | 0.012 | 0.873813 | 0.00011308 | 0.032942 | Nivel 2 | 0 | -0.77 | -0.776 | -0.77 | -0.764 | -0.77 | -0.776 | -0.77 | -0.764 | 0.012ø | 0.000211667 | 204 | 12 mmø
915175 | Nivel 2 | 3.464 | 0.032 | 0.316891 | 0.000804127 | 0.0318573 | Nivel 2 | 0 | -0.77 | -0.786 | -0.77 | -0.754 | -0.77 | -0.786 | -0.77 | -0.754 | 0.032ø | 0.000079375 | 7 | 32 mmø
915522 | Nivel 1 | 3.464 | 0.032 | 18.9536 | 0.000804127 | 1.90542 | Nivel 1 | 0 | 3.48 | 3.464 | 3.48 | 3.496 | 3.48 | 3.464 | 3.48 | 3.496 | 0.032ø | 0.000079375 | 146 | 32 mmø
915526 | Nivel 1 | 3.4705 | 0.019 | 2.8297 | 0.000283486 | 0.168906 | Nivel 1 | 0 | 3.48 | 3.4705 | 3.48 | 3.4895 | 3.48 | 3.4705 | 3.48 | 3.4895 | 0.019ø | 0.000133684 | 193 | 19 mmø
915534 | Nivel 1 | 3.464 | 0.032 | 0.632561 | 0.000804127 | 0.063592 | Nivel 1 | 0 | 3.48 | 3.464 | 3.48 | 3.496 | 3.48 | 3.464 | 3.48 | 3.496 | 0.032ø | 0.000079375 | 146 | 32 mmø
917581 | Nivel 1 | 3.474 | 0.012 | 0.99365 | 0.00011308 | 0.0374597 | Nivel 1 | 0 | 3.48 | 3.474 | 3.48 | 3.486 | 3.48 | 3.474 | 3.48 | 3.486 | 0.012ø | 0.000211667 | 197 | 12 mmø
917610 | Nivel 1 | 3.474 | 0.012 | 1.93643 | 0.00011308 | 0.0730017 | Nivel 1 | 0 | 3.48 | 3.474 | 3.48 | 3.486 | 3.48 | 3.474 | 3.48 | 3.486 | 0.012ø | 0.000211667 | 3 | 12 mmø
919053 | Nivel 1 | 4.40116 | 0.012 | 0.0488418 | 0.00011308 | 0.00184129 | Nivel 1 |  | 4.45 | 4.40116 | 4.40116 | 4.40116 | 4.40116 | 4.45 | 4.45 | 4.45 | 0.012ø | 0.000211667 | 195 | 12 mmø
920357 | Nivel 1 | 3.49394 | 0.012 | 0.839283 | 0.00011308 | 0.0316402 | Nivel 1 |  | 4.33322 | 3.49394 | 3.49394 | 3.49394 | 3.49394 | 4.33322 | 4.33322 | 4.33322 | 0.012ø | 0.000211667 | 3 | 12 mmø
920430 | Nivel 1 | 4.40186 | 0.012 | 0.0481411 | 0.00011308 | 0.00181488 | Nivel 1 |  | 4.45 | 4.40186 | 4.40186 | 4.40186 | 4.40186 | 4.45 | 4.45 | 4.45 | 0.012ø | 0.000211667 | 198 | 12 mmø
920458 | Nivel 1 | 3.49394 | 0.012 | 0.839984 | 0.00011308 | 0.0316666 | Nivel 1 |  | 4.33392 | 3.49394 | 3.49394 | 3.49394 | 3.49394 | 4.33392 | 4.33392 | 4.33392 | 0.012ø | 0.000211667 | 197 | 12 mmø
920514 | Nivel 1 | 3.474 | 0.012 | 2.07958 | 0.00011308 | 0.0783983 | Nivel 1 | 0 | 3.48 | 3.474 | 3.48 | 3.486 | 3.48 | 3.474 | 3.48 | 3.486 | 0.012ø | 0.000211667 | 147 | 12 mmø
920521 | Nivel 1 | 3.474 | 0.012 | 2.89012 | 0.00011308 | 0.108955 | Nivel 1 | 0 | 3.48 | 3.474 | 3.48 | 3.486 | 3.48 | 3.474 | 3.48 | 3.486 | 0.012ø | 0.000211667 | 138 | 12 mmø
920531 | Nivel 1 | 3.474 | 0.012 | 0.146607 | 0.00011308 | 0.00552696 | Nivel 1 | 0 | 3.48 | 3.474 | 3.48 | 3.486 | 3.48 | 3.474 | 3.48 | 3.486 | 0.012ø | 0.000211667 | 147 | 12 mmø
920533 | Nivel 1 | 3.4705 | 0.019 | 0.241728 | 0.000283486 | 0.0144288 | Nivel 1 | 0 | 3.48 | 3.4705 | 3.48 | 3.4895 | 3.48 | 3.4705 | 3.48 | 3.4895 | 0.019ø | 0.000133684 | 214 | 19 mmø
920541 | Nivel 1 | 3.474 | 0.012 | 2.007 | 0.00011308 | 0.0756623 | Nivel 1 | 0 | 3.48 | 3.474 | 3.48 | 3.486 | 3.48 | 3.474 | 3.48 | 3.486 | 0.012ø | 0.000211667 | 138 | 12 mmø
920568 | Nivel 1 | 4.42397 | 0.012 | 0.0260313 | 0.00011308 | 0.000981355 | Nivel 1 |  | 4.45 | 4.42397 | 4.42397 | 4.42397 | 4.42397 | 4.45 | 4.45 | 4.45 | 0.012ø | 0.000211667 | 140 | 12 mmø
920583 | Nivel 1 | 4.42397 | 0.012 | 0.0260313 | 0.00011308 | 0.000981355 | Nivel 1 |  | 4.45 | 4.42397 | 4.42397 | 4.42397 | 4.42397 | 4.45 | 4.45 | 4.45 | 0.012ø | 0.000211667 | 142 | 12 mmø
920652 | Nivel 1 | 3.49394 | 0.012 | 0.862094 | 0.00011308 | 0.0325002 | Nivel 1 |  | 4.35603 | 3.49394 | 3.49394 | 3.49394 | 3.49394 | 4.35603 | 4.35603 | 4.35603 | 0.012ø | 0.000211667 | 138 | 12 mmø
920784 | Nivel 1 | 3.49394 | 0.012 | 0.862094 | 0.00011308 | 0.0325002 | Nivel 1 |  | 4.35603 | 3.49394 | 3.49394 | 3.49394 | 3.49394 | 4.35603 | 4.35603 | 4.35603 | 0.012ø | 0.000211667 | 147 | 12 mmø
920835 | Nivel 1 | 4.40397 | 0.012 | 0.0460313 | 0.00011308 | 0.00173534 | Nivel 1 |  | 4.45 | 4.40397 | 4.40397 | 4.40397 | 4.40397 | 4.45 | 4.45 | 4.45 | 0.012ø | 0.000211667 | 206 | 12 mmø
920958 | Nivel 1 | 3.49394 | 0.012 | 0.842094 | 0.00011308 | 0.0317462 | Nivel 1 |  | 4.33603 | 3.49394 | 3.49394 | 3.49394 | 3.49394 | 4.33603 | 4.33603 | 4.33603 | 0.012ø | 0.000211667 | 204 | 12 mmø
921976 | Nivel 1 | 3.4675 | 0.025 | 4.90569 | 0.0004908 | 0.385292 | Nivel 1 | 0 | 3.48 | 3.4675 | 3.48 | 3.4925 | 3.48 | 3.4675 | 3.48 | 3.4925 | 0.025ø | 0.0001016 | 222 | 25 mmø
921983 | Nivel 1 | 3.4675 | 0.025 | 5.19501 | 0.0004908 | 0.408015 | Nivel 1 | 0 | 3.48 | 3.4675 | 3.48 | 3.4925 | 3.48 | 3.4675 | 3.48 | 3.4925 | 0.025ø | 0.0001016 | 222 | 25 mmø
922114 | Nivel 1 | 3.464 | 0.032 | 0.627618 | 0.000804127 | 0.063095 | Nivel 1 | 0 | 3.48 | 3.464 | 3.48 | 3.496 | 3.48 | 3.464 | 3.48 | 3.496 | 0.032ø | 0.000079375 | 217 | 32 mmø
922148 | Nivel 1 | -0.424016 | 0.025 | 9.73985 | 0.0004908 | 0.764966 | Nivel 1 | 0 | -0.411516 | -0.424016 | -0.411516 | -0.399016 | -0.411516 | -0.424016 | -0.411516 | -0.399016 | 0.025ø | 0.0001016 | 222 | 25 mmø
922742 | Nivel 1 | -0.390878 | 0.025 | 2.81024 | 0.0004908 | 0.220716 | Nivel 1 |  | 2.41936 | -0.390878 | -0.390878 | -0.390878 | -0.390878 | 2.41936 | 2.41936 | 2.41936 | 0.025ø | 0.0001016 | 222 | 25 mmø
922756 | Nivel 1 | 2.4275 | 0.025 | 0.596151 | 0.0004908 | 0.0468216 | Nivel 1 | 0 | 2.44 | 2.4275 | 2.44 | 2.4525 | 2.44 | 2.4275 | 2.44 | 2.4525 | 0.025ø | 0.0001016 | 222 | 25 mmø
922970 | Nivel 1 | 2.4275 | 0.025 | 0.553725 | 0.0004908 | 0.0434895 | Nivel 1 | 0 | 2.44 | 2.4275 | 2.44 | 2.4525 | 2.44 | 2.4275 | 2.44 | 2.4525 | 0.025ø | 0.0001016 | 222 | 25 mmø
923946 | Nivel 1 | 3.4705 | 0.019 | 6.6458 | 0.000283486 | 0.396689 | Nivel 1 | 0 | 3.48 | 3.4705 | 3.48 | 3.4895 | 3.48 | 3.4705 | 3.48 | 3.4895 | 0.019ø | 0.000133684 | 149 | 19 mmø
923958 | Nivel 1 | 3.4705 | 0.019 | 1.57531 | 0.000283486 | 0.0940306 | Nivel 1 | 0 | 3.48 | 3.4705 | 3.48 | 3.4895 | 3.48 | 3.4705 | 3.48 | 3.4895 | 0.019ø | 0.000133684 | 202 | 19 mmø
924031 | Nivel 1 | 3.4705 | 0.019 | 6.32962 | 0.000283486 | 0.377816 | Nivel 1 | 0 | 3.48 | 3.4705 | 3.48 | 3.4895 | 3.48 | 3.4705 | 3.48 | 3.4895 | 0.019ø | 0.000133684 | 192 | 19 mmø
945384 | Nivel 1 | 2.41284 | 0.025 | 0.00651895 | 0.0004908 | 0.000511997 | Nivel 1 |  | 2.41284 | 2.41284 | 2.41284 | 2.41284 | 2.41936 | 2.41936 | 2.41936 | 2.41936 | 0.025ø | 0.0001016 | 222 | 25 mmø
945391 | Nivel 1 | 2.4275 | 0.025 | 0.318725 | 0.0004908 | 0.0250326 | Nivel 1 | 0 | 2.44 | 2.4275 | 2.44 | 2.4525 | 2.44 | 2.4275 | 2.44 | 2.4525 | 0.025ø | 0.0001016 | 222 | 25 mmø
945409 | Nivel 1 | 2.4275 | 0.025 | 1.25873 | 0.0004908 | 0.09886 | Nivel 1 | 0 | 2.44 | 2.4275 | 2.44 | 2.4525 | 2.44 | 2.4275 | 2.44 | 2.4525 | 0.025ø | 0.0001016 | 222 | 25 mmø
945433 | Nivel 1 | 0.7 | 0.025 | 1.71936 | 0.0004908 | 0.135038 | Nivel 1 |  | 0.7 | 0.7 | 0.7 | 0.7 | 2.41936 | 2.41936 | 2.41936 | 2.41936 | 0.025ø | 0.0001016 | 222 | 25 mmø
945560 | Nivel 1 | 2.37971 | 0.025 | 0.443676 | 0.0004908 | 0.0348463 | Nivel 1 | 0 | 2.39221 | 2.37971 | 2.39221 | 2.40471 | 2.39221 | 2.37971 | 2.39221 | 2.40471 | 0.025ø | 0.0001016 | 222 | 25 mmø
945572 | Nivel 1 | 2.41284 | 0.025 | 0.00651895 | 0.0004908 | 0.000511997 | Nivel 1 |  | 2.41284 | 2.41284 | 2.41284 | 2.41284 | 2.41936 | 2.41936 | 2.41936 | 2.41936 | 0.025ø | 0.0001016 | 222 | 25 mmø
954059 | Nivel 1 | 4.33938 | 0.012 | 0.160625 | 0.00011308 | 0.00605542 | Nivel 1 |  | 4.5 | 4.33938 | 4.33938 | 4.33938 | 4.33938 | 4.5 | 4.5 | 4.5 | 0.012ø | 0.000211667 | 209 | 12 mmø
954086 | Nivel 1 | 3.49394 | 0.012 | 0.7775 | 0.00011308 | 0.0293111 | Nivel 1 |  | 4.27144 | 3.49394 | 3.49394 | 3.49394 | 3.49394 | 4.27144 | 4.27144 | 4.27144 | 0.012ø | 0.000211667 | 203 | 12 mmø
954229 | Nivel 1 | 3.474 | 0.012 | 1.08282 | 0.00011308 | 0.0408213 | Nivel 1 | 0 | 3.48 | 3.474 | 3.48 | 3.486 | 3.48 | 3.474 | 3.48 | 3.486 | 0.012ø | 0.000211667 | 197 | 12 mmø
954244 | Nivel 1 | 3.474 | 0.012 | 0.450295 | 0.00011308 | 0.0169757 | Nivel 1 | 0 | 3.48 | 3.474 | 3.48 | 3.486 | 3.48 | 3.474 | 3.48 | 3.486 | 0.012ø | 0.000211667 | 197 | 12 mmø
955087 | Nivel 1 | 3.4705 | 0.019 | 6.88391 | 0.000283486 | 0.410902 | Nivel 1 | 0 | 3.48 | 3.4705 | 3.48 | 3.4895 | 3.48 | 3.4705 | 3.48 | 3.4895 | 0.019ø | 0.000133684 | 214 | 19 mmø
955102 | Nivel 1 | 3.464 | 0.032 | 19.2257 | 0.000804127 | 1.93278 | Nivel 1 | 0 | 3.48 | 3.464 | 3.48 | 3.496 | 3.48 | 3.464 | 3.48 | 3.496 | 0.032ø | 0.000079375 | 7 | 32 mmø
956389 | Nivel 1 | -1.5073 | 0.025 | 0.118771 | 0.0004908 | 0.00932829 | Nivel 1 | 0 | -1.4948 | -1.5073 | -1.4948 | -1.4823 | -1.4948 | -1.5073 | -1.4948 | -1.4823 | 0.025ø | 0.0001016 | 222 | 25 mmø
956403 | Nivel 1 | -1.5073 | 0.025 | 0.173149 | 0.0004908 | 0.0135991 | Nivel 1 | 0 | -1.4948 | -1.5073 | -1.4948 | -1.4823 | -1.4948 | -1.5073 | -1.4948 | -1.4823 | 0.025ø | 0.0001016 | 222 | 25 mmø
956697 | Nivel 1 | -1.5073 | 0.025 | 12.7422 | 0.000490782 | 1.00077 | Nivel 1 | 0 | -1.49479 | -1.5073 | -1.4948 | -1.4823 | -1.4948 | -1.50729 | -1.49479 | -1.48229 | 0.025ø | 0.0001016 | 222 | 25 mmø
956778 | Nivel 1 | 3.7302 | 0.025 | 1.45637 | 0.0004908 | 0.114383 | Nivel 1 | 0 | 3.7427 | 3.7302 | 3.7427 | 3.7552 | 3.74271 | 3.73021 | 3.74271 | 3.75521 | 0.025ø | 0.0001016 | 222 | 25 mmø
956925 | Nivel 1 | -1.47415 | 0.025 | 5.19621 | 0.0004908 | 0.40811 | Nivel 1 |  | 3.72207 | -1.47415 | -1.47415 | -1.47415 | -1.47415 | 3.72207 | 3.72207 | 3.72207 | 0.025ø | 0.0001016 | 222 | 25 mmø
957169 | Nivel 1 | 3.50064 | 0.025 | 0.221431 | 0.0004908 | 0.0173911 | Nivel 1 |  | 3.50064 | 3.50064 | 3.50064 | 3.50064 | 3.72207 | 3.72207 | 3.72207 | 3.72207 | 0.025ø | 0.0001016 | 222 | 25 mmø
957348 | Nivel 1 | -1.47416 | 0.025 | 1.04201 | 0.0004908 | 0.0818391 | Nivel 1 |  | -1.47416 | -1.47416 | -1.47416 | -1.47416 | -0.432153 | -0.432153 | -0.432153 | -0.432153 | 0.025ø | 0.0001016 | 222 | 25 mmø

# IfcPipeSegment: Pipe Types:Aire Medicinal (197)
In: Nivel 1
Type - Other - Category: Pipes; Family Name: Pipe Types
Type - Identity Data - Type Name: Aire Medicinal
Material: Cobre
Pset_EnvironmentalImpactIndicators - Reference: Pipe Types:Aire Medicinal; sets with these values: 2
Other - Family: Pipe Types; Family and Type: Pipe Types: Aire Medicinal; Type: Aire Medicinal; Type Id: 142438
Constraints - Horizontal Justification: Center; Reference Level: Nivel 1; Vertical Justification: Middle
Dimensions - Wall Thickness: 0 m
Mechanical - Connection Type: Generic; Material: Cobre; Pipe Segment: Cobre - A; Roughness: 0.00000254 m; Schedule/Type: A
Mechanical - Flow - Additional Flow: 0 dm3/s; Flow: 0 dm3/s; Flow State: Laminar; Friction: 0; Friction Factor: 0; Pressure Drop: 0 Pa; Reynolds Number: 0; Velocity: 0 m/s; Velocity Pressure: 0 Pa
Phasing - Phase Created: Nueva construcción
Insulation - Insulation Thickness: 0 m
AboveGround - AboveGround: yes
Name (Pipe Types:Aire Medicinal:...) | Classification | InvertElevation (m) = Lower End Bottom Elevation (m) = Lower End Invert Elevation (m) = Invert Elevation (m) = Lower End Bottom of Insulation Elevation (m) | Pset_FlowSegmentDiameter, Diameter (m) = Inside Diameter (m) = Outside Diameter (m) = Mechanical, Diameter (m) | Qto_PipeSegmentBaseQuantities, Length (m) = Dimensions, Length (m) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) = Area (m2) | End Middle Elevation (m) | Lower End Centerline Elevation (m) | Lower End Obvert Elevation (m) = Lower End Top Elevation (m) = Lower End Top of Insulation Elevation (m) | Middle Elevation (m) = Start Middle Elevation (m) | Slope | Upper End Bottom Elevation (m) = Upper End Invert Elevation (m) = Upper End Bottom of Insulation Elevation (m) | Upper End Centerline Elevation (m) | Upper End Obvert Elevation (m) = Upper End Top Elevation (m) = Upper End Top of Insulation Elevation (m) | Size | System Classification | System Name = Group | System Type | Relative Roughness | Section | Overall Size
909914 | D2022 (FEMAP58) | 3.474 | 0.012 | 2.95232 | 0.00011308 | 0.1113 | 3.48 | 3.48 | 3.486 | 3.48 | 0 | 3.474 | 3.48 | 3.486 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 1 | 12 mmø
909923 | D2022 (FEMAP58) | 3.474 | 0.012 | 2.34952 | 0.00011308 | 0.0885747 | 3.48 | 3.48 | 3.486 | 3.48 | 0 | 3.474 | 3.48 | 3.486 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 1 | 12 mmø
909939 | D2022 (FEMAP58) | 3.474 | 0.012 | 2.86731 | 0.00011308 | 0.108095 | 3.48 | 3.48 | 3.486 | 3.48 | 0 | 3.474 | 3.48 | 3.486 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 1 | 12 mmø
910021 | D2022 (FEMAP58) | 3.474 | 0.012 | 0.371929 | 0.00011308 | 0.0140214 | 3.48 | 3.48 | 3.486 | 3.48 | 0 | 3.474 | 3.48 | 3.486 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 184 | 12 mmø
910028 | D2022 (FEMAP58) | 3.474 | 0.012 | 1.61556 | 0.00011308 | 0.0609054 | 3.48 | 3.48 | 3.486 | 3.48 | 0 | 3.474 | 3.48 | 3.486 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 184 | 12 mmø
910038 | D2022 (FEMAP58) | 3.474 | 0.012 | 0.8976 | 0.00011308 | 0.0338387 | 3.48 | 3.48 | 3.486 | 3.48 | 0 | 3.474 | 3.48 | 3.486 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 184 | 12 mmø
