Properties of the parts of a building model (IFC4), part 3 of 6

# IfcDistributionPort (1740)
Name | FlowDirection | PredefinedType | SystemType | Group
Port_953230_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_953226_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_953228_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_953226_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_953230_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_953245_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_953288_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_953245_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_953290_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
InPort_953290_1 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_953254_0 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
Port_953290_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_953291_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_953317_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_953327_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_953317_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_953361_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_953358_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_953361_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_953358_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
InPort_953409_0 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_953438_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_953442_2 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_953409_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_953425_0 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_953427_3 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_953438_1 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_953425_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_953427_1 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_953431_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_953427_2 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_953434_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_953434_2 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_953428_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_953451_0 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_953474_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_953478_1 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_953451_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_953462_0 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_953464_3 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_953474_1 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_953462_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_953464_1 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_953468_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_953464_2 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_953470_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_953470_2 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_953465_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
Port_954059_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_954125_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_954059_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_954064_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_954086_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_954084_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_954125_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_954084_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_954127_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_954086_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_954127_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_954229_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_954252_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_954244_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_954252_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_954244_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_954262_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_955087_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_955109_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_955087_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_955111_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_955101_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_955102_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_955101_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_955109_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_956389_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_957352_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_956389_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_957357_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_956403_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_957357_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_956403_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_956545_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_956450_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_957364_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_956450_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_956554_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_956460_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_956552_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_956460_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_956554_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_956506_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_957380_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_956506_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_957385_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_956516_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_957385_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_956516_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_956557_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_956545_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_956697_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_956552_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_956683_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_956557_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_956646_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_956646_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_956996_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_956683_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_956962_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_956697_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_956927_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_956778_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_957306_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_956778_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_956939_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_956834_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_957280_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_956834_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_957285_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_956890_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_957242_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_956890_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_957247_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_956925_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_956927_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_956925_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_956939_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_956960_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_956962_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_956960_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_957285_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_956994_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_956996_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_956994_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_957247_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_957155_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_957192_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_957155_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_957242_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_957162_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_957270_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_957162_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_957280_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_957169_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_957306_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_957169_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_957311_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_957348_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_957350_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_957348_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_957352_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_957362_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_957364_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_957362_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_957366_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_957376_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_957378_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_957376_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_957380_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1

# IfcDistributionSystem: Agua fría doméstica, Agua fría doméstica 1
PredefinedType: DOMESTICCOLDWATER
Pset_DistributionSystemCommon - Reference: Piping System:Agua fría doméstica

# IfcDistributionSystem: Suministro hidrónico (4)
PredefinedType: HEATING
Pset_DistributionSystemCommon - Reference: Piping System:Suministro hidrónico
Name
Suministro hidrónico 1
Suministro hidrónico 3
Suministro hidrónico 18
Suministro hidrónico 4

# IfcFlowTerminal: Salida gases:Salida gases (26)
In: Nivel 1
Type - Material: <Unnamed>
Type - Other - Category: Mechanical Equipment; Family Name: Salida gases
Type - Constraints - Default Elevation: 0 m
Type - Dimensions - Entrada: 0.012 m
Type - Identity Data - Type Name: Salida gases
Classification: D202 (FEMAP58); Group: Suministro hidrónico 1; Suministro hidrónico 3
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: Salida gases:Salida gases
Pset_EnvironmentalImpactIndicators - Reference: Salida gases:Salida gases
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.203811 m2; NetVolume: 0.00228561 m3
Other - Family: Salida gases; Family and Type: Salida gases: Salida gases; Type: Salida gases; Type Id: 934763
Constraints - Level: Nivel 1; Elevation from Level: 1.5 m; Host: Level : Nivel 1; Offset from Host: 1.5 m
Dimensions - Area: 0.101906 m2; Volume: 0.00228561 m3
Mechanical - System Classification: Hydronic Supply; System Name: Suministro hidrónico 3,Suministro hidrónico 1
Phasing - Phase Created: Nueva construcción
AboveGround - AboveGround: yes
Name (Salida gases:Salida gases:...) | Mark
936045 | 3
936233 | 4
936264 | 5
936292 | 6
936318 | 7
936344 | 8
936370 | 9
936398 | 10
936424 | 11
936452 | 12
936956 | 14
937149 | 15
937273 | 16
937305 | 17
937331 | 18
937543 | 20
937581 | 21
937609 | 22
937635 | 23
937675 | 24
937701 | 25
937729 | 26
937937 | 27
937986 | 28
938010 | 29
938105 | 30

# IfcGrid (2)
AboveGround - AboveGround: yes
Name | In
Default Grid | Nivel 1
Default Grid | Nivel 2

# IfcPipeFitting: M_Codo - Genérico:Norma (210)
Type - Material: <Unnamed>
Type - Other - Category: Pipe Fittings; Family Name: M_Codo - Genérico; Nombre de tabla de consulta: M_Pipe Fitting - Generic
Type - Constraints - Default Elevation: 0 m
Type - Identity Data - OmniClass Number: 23.60.30.11.14; OmniClass Title: Pipework Fittings; Type Name: Norma
Type - Mechanical - Connection Type: Generic; K Coefficient Table: Regular 45, 90 and 180 Elbow; Loss Method: K Coefficient from Table
Classification: D2022.0 (FEMAP58)
Pset_EnvironmentalImpactIndicators - Reference: M_Codo - Genérico:Norma; sets with these values: 2
Other - Family: M_Codo - Genérico; Family and Type: M_Codo - Genérico: Norma; Type: Norma; Type Id: 133158
Graphics - Use Annotation Scale: yes
Mechanical - System Type: Suministro hidrónico; System Classification: Hydronic Supply
Phasing - Phase Created: Nueva construcción
Insulation - Insulation Thickness: 0 m
AboveGround - AboveGround: yes
Name (M_Codo - Genérico:Norma:...) | In | Radio central (m) | Radio exterior de unión (m) | Elevation from Level (m) | Level | Ángulo (deg) | Centro a extremo (m) | Diámetro exterior de unión (m) | Diámetro nominal (m) = Maximum Size (m) = Minimum Size (m) | Radio nominal (m) | Size | Tamaño de marca (m) | Volume (m3) | System Name = Group | Overall Size
909945 | Nivel 1 | 0.0139375 | 0.0075875 | 3.48 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 1 | 12 mmø-12 mmø
909961 | Nivel 1 | 0.0139375 | 0.0075875 | 3.48 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 1 | 12 mmø-12 mmø
910036 | Nivel 1 | 0.0139375 | 0.0075875 | 3.48 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 1 | 12 mmø-12 mmø
910044 | Nivel 1 | 0.0139375 | 0.0075875 | 3.48 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 1 | 12 mmø-12 mmø
910054 | Nivel 1 | 0.0139375 | 0.0075875 | 3.48 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 1 | 12 mmø-12 mmø
910134 | Nivel 1 | 0.0139375 | 0.0075875 | 3.45 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 3 | 12 mmø-12 mmø
910223 | Nivel 1 | 0.0139375 | 0.0075875 | 3.45 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 3 | 12 mmø-12 mmø
910244 | Nivel 1 | 0.0174375 | 0.0110875 | 3.45 | Nivel 1 | 90 | 0.0174375 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø | 0.00887 | 0.0000105781 | Suministro hidrónico 3 | 19 mmø-19 mmø
911540 | Nivel 1 | 0.0139375 | 0.0075875 | 4.8 | Nivel 1 | 45 | 0.0057731 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00251428 | 0.00000197972 | Suministro hidrónico 18 | 12 mmø-12 mmø
911856 | Nivel 1 | 0.0139375 | 0.0075875 | 3.45 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 3 | 12 mmø-12 mmø
916328 | Nivel 1 | 0.0139375 | 0.0075875 | 3.48 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 1 | 12 mmø-12 mmø
917107 | Nivel 1 | 0.0206375 | 0.0142875 | 3.45 | Nivel 1 | 90 | 0.0206375 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø | 0.01143 | 0.0000207886 | Suministro hidrónico 3 | 25 mmø-25 mmø
917483 | Nivel 1 | 0.0174375 | 0.0110875 | 3.45 | Nivel 1 | 90 | 0.0174375 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø | 0.00887 | 0.0000105781 | Suministro hidrónico 3 | 19 mmø-19 mmø
917556 | Nivel 1 | 0.0174375 | 0.0110875 | 3.45 | Nivel 1 | 90 | 0.0174375 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø | 0.00887 | 0.0000105781 | Suministro hidrónico 3 | 19 mmø-19 mmø
917558 | Nivel 1 | 0.0174375 | 0.0110875 | 3.48 | Nivel 1 | 90 | 0.0174375 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø | 0.00887 | 0.0000105781 | Suministro hidrónico 1 | 19 mmø-19 mmø
917560 | Nivel 1 | 0.0206375 | 0.0142875 | 3.48 | Nivel 1 | 90 | 0.0206375 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø | 0.01143 | 0.0000207886 | Suministro hidrónico 1 | 25 mmø-25 mmø
920529 | Nivel 1 | 0.0139375 | 0.0075875 | 3.48 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 4 | 12 mmø-12 mmø
920547 | Nivel 1 | 0.0139375 | 0.0075875 | 3.48 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 4 | 12 mmø-12 mmø
920571 | Nivel 1 | 0.0139375 | 0.0075875 | 3.48 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 4 | 12 mmø-12 mmø
920586 | Nivel 1 | 0.0139375 | 0.0075875 | 3.48 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 4 | 12 mmø-12 mmø
921278 | Nivel 1 | 0.0206375 | 0.0142875 | 3.45 | Nivel 1 | 90 | 0.0206375 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø | 0.01143 | 0.0000207886 | Suministro hidrónico 3 | 25 mmø-25 mmø
921328 | Nivel 1 | 0.0206375 | 0.0142875 | 3.48 | Nivel 1 | 90 | 0.0206375 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø | 0.01143 | 0.0000207886 | Suministro hidrónico 1 | 25 mmø-25 mmø
922111 | Nivel 1 | 0.0206375 | 0.0142875 | 3.48 | Nivel 1 | 90 | 0.0206375 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø | 0.01143 | 0.0000207886 | Suministro hidrónico 4 | 25 mmø-25 mmø
922686 | Nivel 1 | 0.0206375 | 0.0142875 | -0.411515 | Nivel 1 | 90 | 0.0206375 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø | 0.01143 | 0.0000207886 | Suministro hidrónico 1 | 25 mmø-25 mmø
922752 | Nivel 1 | 0.0206375 | 0.0142875 | -0.411516 | Nivel 1 | 90 | 0.0206375 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø | 0.01143 | 0.0000207886 | Suministro hidrónico 4 | 25 mmø-25 mmø
923067 | Nivel 1 | 0.0206375 | 0.0142875 | 2.44 | Nivel 1 | 90 | 0.0206375 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø | 0.01143 | 0.0000207886 | Suministro hidrónico 4 | 25 mmø-25 mmø
923098 | Nivel 1 | 0.0206375 | 0.0142875 | 2.44 | Nivel 1 | 90 | 0.0206375 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø | 0.01143 | 0.0000207886 | Suministro hidrónico 3 | 25 mmø-25 mmø
923102 | Nivel 1 | 0.0206375 | 0.0142875 | 2.44 | Nivel 1 | 90 | 0.0206375 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø | 0.01143 | 0.0000207886 | Suministro hidrónico 3 | 25 mmø-25 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
923432 | Nivel 1 | 0.0206375 | 0.0142875 | 3.48 | Nivel 1 | 90 | 0.0206375 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø | 0.01143 | 0.0000207886 | Suministro hidrónico 1 | 25 mmø-25 mmø
923522 | Nivel 1 | 0.0206375 | 0.0142875 | 3.45 | Nivel 1 | 90 | 0.0206375 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø | 0.01143 | 0.0000207886 | Suministro hidrónico 3 | 25 mmø-25 mmø
923906 | Nivel 1 | 0.0139375 | 0.0075875 | 3.48 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 4 | 12 mmø-12 mmø
923955 | Nivel 2 | 0.0139375 | 0.0075875 | -0.77 | Nivel 2 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 4 | 12 mmø-12 mmø
924022 | Nivel 1 | 0.0174375 | 0.0110875 | 3.48 | Nivel 1 | 90 | 0.0174375 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø | 0.00887 | 0.0000105781 | Suministro hidrónico 4 | 19 mmø-19 mmø
924026 | Nivel 1 | 0.0139375 | 0.0075875 | 3.48 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 4 | 12 mmø-12 mmø
924632 | Nivel 1 | 0.0139375 | 0.0075875 | 3.48 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 4 | 12 mmø-12 mmø
924636 | Nivel 2 | 0.0139375 | 0.0075875 | -0.77 | Nivel 2 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 4 | 12 mmø-12 mmø
927723 | Nivel 1 | 0.0174375 | 0.0110875 | 3.48 | Nivel 1 | 90 | 0.0174375 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø | 0.00887 | 0.0000105781 | Suministro hidrónico 1 | 19 mmø-19 mmø
927879 | Nivel 1 | 0.0174375 | 0.0110875 | 3.48 | Nivel 1 | 90 | 0.0174375 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø | 0.00887 | 0.0000105781 | Suministro hidrónico 1 | 19 mmø-19 mmø
927887 | Nivel 1 | 0.0174375 | 0.0110875 | 1.6 | Nivel 1 | 90 | 0.0174375 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø | 0.00887 | 0.0000105781 | Suministro hidrónico 1 | 19 mmø-19 mmø
927912 | Nivel 1 | 0.0174375 | 0.0110875 | 3.48 | Nivel 1 | 90 | 0.0174375 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø | 0.00887 | 0.0000105781 | Suministro hidrónico 1 | 19 mmø-19 mmø
927914 | Nivel 1 | 0.0174375 | 0.0110875 | 1.6 | Nivel 1 | 90 | 0.0174375 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø | 0.00887 | 0.0000105781 | Suministro hidrónico 1 | 19 mmø-19 mmø
928414 | Nivel 1 | 0.0174375 | 0.0110875 | 3.45 | Nivel 1 | 90 | 0.0174375 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø | 0.00887 | 0.0000105781 | Suministro hidrónico 3 | 19 mmø-19 mmø
928416 | Nivel 1 | 0.0174375 | 0.0110875 | 3.45 | Nivel 1 | 90 | 0.0174375 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø | 0.00887 | 0.0000105781 | Suministro hidrónico 3 | 19 mmø-19 mmø
928420 | Nivel 1 | 0.0174375 | 0.0110875 | 1.73157 | Nivel 1 | 90 | 0.0174375 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø | 0.00887 | 0.0000105781 | Suministro hidrónico 3 | 19 mmø-19 mmø
928470 | Nivel 1 | 0.0174375 | 0.0110875 | 3.45 | Nivel 1 | 90 | 0.0174375 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø | 0.00887 | 0.0000105781 | Suministro hidrónico 3 | 19 mmø-19 mmø
928472 | Nivel 1 | 0.0174375 | 0.0110875 | 3.45 | Nivel 1 | 90 | 0.0174375 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø | 0.00887 | 0.0000105781 | Suministro hidrónico 3 | 19 mmø-19 mmø
928474 | Nivel 1 | 0.0174375 | 0.0110875 | 1.73157 | Nivel 1 | 90 | 0.0174375 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø | 0.00887 | 0.0000105781 | Suministro hidrónico 3 | 19 mmø-19 mmø
933505 | Nivel 1 | 0.0174375 | 0.0110875 | 3.45 | Nivel 1 | 90 | 0.0174375 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø | 0.00887 | 0.0000105781 | Suministro hidrónico 3 | 19 mmø-19 mmø
933531 | Nivel 1 | 0.0174375 | 0.0110875 | 3.45 | Nivel 1 | 90 | 0.0174375 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø | 0.00887 | 0.0000105781 | Suministro hidrónico 3 | 19 mmø-19 mmø
933555 | Nivel 1 | 0.0174375 | 0.0110875 | 1.6 | Nivel 1 | 90 | 0.0174375 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø | 0.00887 | 0.0000105781 | Suministro hidrónico 1 | 19 mmø-19 mmø
933582 | Nivel 1 | 0.0174375 | 0.0110875 | 3.48 | Nivel 1 | 90 | 0.0174375 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø | 0.00887 | 0.0000105781 | Suministro hidrónico 1 | 19 mmø-19 mmø
933584 | Nivel 1 | 0.0174375 | 0.0110875 | 1.6 | Nivel 1 | 90 | 0.0174375 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø | 0.00887 | 0.0000105781 | Suministro hidrónico 1 | 19 mmø-19 mmø
933631 | Nivel 1 | 0.0174375 | 0.0110875 | 1.72 | Nivel 1 | 90 | 0.0174375 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø | 0.00887 | 0.0000105781 | Suministro hidrónico 3 | 19 mmø-19 mmø
933656 | Nivel 1 | 0.0174375 | 0.0110875 | 3.45 | Nivel 1 | 90 | 0.0174375 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø | 0.00887 | 0.0000105781 | Suministro hidrónico 3 | 19 mmø-19 mmø
933658 | Nivel 1 | 0.0174375 | 0.0110875 | 3.45 | Nivel 1 | 90 | 0.0174375 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø | 0.00887 | 0.0000105781 | Suministro hidrónico 3 | 19 mmø-19 mmø
933662 | Nivel 1 | 0.0174375 | 0.0110875 | 1.72 | Nivel 1 | 90 | 0.0174375 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø | 0.00887 | 0.0000105781 | Suministro hidrónico 3 | 19 mmø-19 mmø
936510 | Nivel 1 | 0.0139375 | 0.0075875 | 3.48 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 1 | 12 mmø-12 mmø
936512 | Nivel 1 | 0.0139375 | 0.0075875 | 3.48 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 1 | 12 mmø-12 mmø
936529 | Nivel 1 | 0.0139375 | 0.0075875 | 3.45 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 3 | 12 mmø-12 mmø
936531 | Nivel 1 | 0.0139375 | 0.0075875 | 3.45 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 3 | 12 mmø-12 mmø
936552 | Nivel 1 | 0.0139375 | 0.0075875 | 3.45 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 3 | 12 mmø-12 mmø
936554 | Nivel 1 | 0.0139375 | 0.0075875 | 3.45 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 3 | 12 mmø-12 mmø
936571 | Nivel 1 | 0.0139375 | 0.0075875 | 3.48 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 1 | 12 mmø-12 mmø
936573 | Nivel 1 | 0.0139375 | 0.0075875 | 3.48 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 1 | 12 mmø-12 mmø
936598 | Nivel 1 | 0.0139375 | 0.0075875 | 3.45 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 3 | 12 mmø-12 mmø
936619 | Nivel 1 | 0.0139375 | 0.0075875 | 3.48 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 1 | 12 mmø-12 mmø
936650 | Nivel 1 | 0.0139375 | 0.0075875 | 3.45 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 3 | 12 mmø-12 mmø
936671 | Nivel 1 | 0.0139375 | 0.0075875 | 3.48 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 1 | 12 mmø-12 mmø
936698 | Nivel 1 | 0.0139375 | 0.0075875 | 3.45 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 3 | 12 mmø-12 mmø
936700 | Nivel 1 | 0.0139375 | 0.0075875 | 3.45 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 3 | 12 mmø-12 mmø
936717 | Nivel 1 | 0.0139375 | 0.0075875 | 3.48 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 1 | 12 mmø-12 mmø
936719 | Nivel 1 | 0.0139375 | 0.0075875 | 3.48 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 1 | 12 mmø-12 mmø
936740 | Nivel 1 | 0.0139375 | 0.0075875 | 3.48 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 1 | 12 mmø-12 mmø
936742 | Nivel 1 | 0.0139375 | 0.0075875 | 3.48 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 1 | 12 mmø-12 mmø
936759 | Nivel 1 | 0.0139375 | 0.0075875 | 3.45 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 3 | 12 mmø-12 mmø
936761 | Nivel 1 | 0.0139375 | 0.0075875 | 3.45 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 3 | 12 mmø-12 mmø
936782 | Nivel 1 | 0.0139375 | 0.0075875 | 3.48 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 1 | 12 mmø-12 mmø
936784 | Nivel 1 | 0.0139375 | 0.0075875 | 3.48 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 1 | 12 mmø-12 mmø
936801 | Nivel 1 | 0.0139375 | 0.0075875 | 3.45 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 3 | 12 mmø-12 mmø
936803 | Nivel 1 | 0.0139375 | 0.0075875 | 3.45 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 3 | 12 mmø-12 mmø
936828 | Nivel 1 | 0.0139375 | 0.0075875 | 3.45 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 3 | 12 mmø-12 mmø
936849 | Nivel 1 | 0.0139375 | 0.0075875 | 3.48 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 1 | 12 mmø-12 mmø
936874 | Nivel 1 | 0.0139375 | 0.0075875 | 3.48 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 1 | 12 mmø-12 mmø
936895 | Nivel 1 | 0.0139375 | 0.0075875 | 3.45 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 3 | 12 mmø-12 mmø
936916 | Nivel 1 | 0.0139375 | 0.0075875 | 3.45 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 3 | 12 mmø-12 mmø
936918 | Nivel 1 | 0.0139375 | 0.0075875 | 3.45 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 3 | 12 mmø-12 mmø
936935 | Nivel 1 | 0.0139375 | 0.0075875 | 3.48 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 1 | 12 mmø-12 mmø
936937 | Nivel 1 | 0.0139375 | 0.0075875 | 3.48 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 1 | 12 mmø-12 mmø
937087 | Nivel 1 | 0.0139375 | 0.0075875 | 3.45 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 3 | 12 mmø-12 mmø
937127 | Nivel 1 | 0.0139375 | 0.0075875 | 3.48 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 1 | 12 mmø-12 mmø
937215 | Nivel 1 | 0.0139375 | 0.0075875 | 3.48 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 1 | 12 mmø-12 mmø
937254 | Nivel 1 | 0.0139375 | 0.0075875 | 3.45 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 3 | 12 mmø-12 mmø
937410 | Nivel 1 | 0.0139375 | 0.0075875 | 3.45 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 3 | 12 mmø-12 mmø
937412 | Nivel 1 | 0.0139375 | 0.0075875 | 3.45 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 3 | 12 mmø-12 mmø
937431 | Nivel 1 | 0.0139375 | 0.0075875 | 3.48 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 1 | 12 mmø-12 mmø
937433 | Nivel 1 | 0.0139375 | 0.0075875 | 3.48 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 1 | 12 mmø-12 mmø
937456 | Nivel 1 | 0.0139375 | 0.0075875 | 3.45 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 3 | 12 mmø-12 mmø
937479 | Nivel 1 | 0.0139375 | 0.0075875 | 3.48 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 1 | 12 mmø-12 mmø
937502 | Nivel 1 | 0.0139375 | 0.0075875 | 3.45 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 3 | 12 mmø-12 mmø
937525 | Nivel 1 | 0.0139375 | 0.0075875 | 3.48 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 1 | 12 mmø-12 mmø
937771 | Nivel 1 | 0.0139375 | 0.0075875 | 3.45 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 3 | 12 mmø-12 mmø
937787 | Nivel 1 | 0.0139375 | 0.0075875 | 3.48 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 1 | 12 mmø-12 mmø
937804 | Nivel 1 | 0.0139375 | 0.0075875 | 3.45 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 3 | 12 mmø-12 mmø
937808 | Nivel 1 | 0.0139375 | 0.0075875 | 3.45 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 3 | 12 mmø-12 mmø
937823 | Nivel 1 | 0.0139375 | 0.0075875 | 3.48 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 1 | 12 mmø-12 mmø
937827 | Nivel 1 | 0.0139375 | 0.0075875 | 3.48 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 1 | 12 mmø-12 mmø
937848 | Nivel 1 | 0.0139375 | 0.0075875 | 3.45 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 3 | 12 mmø-12 mmø
937852 | Nivel 1 | 0.0139375 | 0.0075875 | 3.45 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 3 | 12 mmø-12 mmø
937869 | Nivel 1 | 0.0139375 | 0.0075875 | 3.48 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 1 | 12 mmø-12 mmø
937873 | Nivel 1 | 0.0139375 | 0.0075875 | 3.48 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 1 | 12 mmø-12 mmø
937883 | Nivel 1 | 0.0139375 | 0.0075875 | 3.48 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 1 | 12 mmø-12 mmø
937891 | Nivel 1 | 0.0139375 | 0.0075875 | 3.48 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 1 | 12 mmø-12 mmø
937899 | Nivel 1 | 0.0139375 | 0.0075875 | 3.45 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 3 | 12 mmø-12 mmø
937907 | Nivel 1 | 0.0139375 | 0.0075875 | 3.45 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 3 | 12 mmø-12 mmø
937915 | Nivel 1 | 0.0139375 | 0.0075875 | 3.48 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 1 | 12 mmø-12 mmø
937923 | Nivel 1 | 0.0139375 | 0.0075875 | 3.45 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 3 | 12 mmø-12 mmø
938021 | Nivel 1 | 0.0139375 | 0.0075875 | 3.45 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 3 | 12 mmø-12 mmø
938035 | Nivel 1 | 0.0139375 | 0.0075875 | 3.48 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 1 | 12 mmø-12 mmø
938037 | Nivel 1 | 0.0139375 | 0.0075875 | 3.48 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 1 | 12 mmø-12 mmø
938041 | Nivel 1 | 0.0139375 | 0.0075875 | 3.45 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 3 | 12 mmø-12 mmø
938043 | Nivel 1 | 0.0139375 | 0.0075875 | 3.45 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 3 | 12 mmø-12 mmø
938049 | Nivel 1 | 0.0139375 | 0.0075875 | 3.48 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 1 | 12 mmø-12 mmø
938057 | Nivel 1 | 0.0139375 | 0.0075875 | 3.48 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 1 | 12 mmø-12 mmø
938065 | Nivel 1 | 0.0139375 | 0.0075875 | 3.45 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 3 | 12 mmø-12 mmø
938073 | Nivel 1 | 0.0139375 | 0.0075875 | 3.45 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 3 | 12 mmø-12 mmø
938288 | Nivel 1 | 0.0139375 | 0.0075875 | 3.45 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 3 | 12 mmø-12 mmø
938302 | Nivel 1 | 0.0139375 | 0.0075875 | 3.48 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 1 | 12 mmø-12 mmø
940212 | Nivel 1 | 0.0174375 | 0.0110875 | 2.2 | Nivel 1 | 90 | 0.0174375 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø | 0.00887 | 0.0000105781 | Suministro hidrónico 1 | 19 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
940216 | Nivel 1 | 0.0174375 | 0.0110875 | 2.2 | Nivel 1 | 90 | 0.0174375 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø | 0.00887 | 0.0000105781 | Suministro hidrónico 1 | 19 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
940255 | Nivel 1 | 0.0174375 | 0.0110875 | 2.2 | Nivel 1 | 90 | 0.0174375 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø | 0.00887 | 0.0000105781 | Suministro hidrónico 3 | 19 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
940259 | Nivel 1 | 0.0174375 | 0.0110875 | 2.2 | Nivel 1 | 90 | 0.0174375 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø | 0.00887 | 0.0000105781 | Suministro hidrónico 3 | 19 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
940281 | Nivel 1 | 0.0174375 | 0.0110875 | 2.2 | Nivel 1 | 90 | 0.0174375 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø | 0.00887 | 0.0000105781 | Suministro hidrónico 1 | 19 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
940283 | Nivel 1 | 0.0174375 | 0.0110875 | 2.2 | Nivel 1 | 90 | 0.0174375 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø | 0.00887 | 0.0000105781 | Suministro hidrónico 1 | 19 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
940291 | Nivel 1 | 0.0174375 | 0.0110875 | 2.2 | Nivel 1 | 90 | 0.0174375 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø | 0.00887 | 0.0000105781 | Suministro hidrónico 3 | 19 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
940293 | Nivel 1 | 0.0174375 | 0.0110875 | 2.2 | Nivel 1 | 90 | 0.0174375 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø | 0.00887 | 0.0000105781 | Suministro hidrónico 3 | 19 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
940318 | Nivel 1 | 0.0174375 | 0.0110875 | 2.2 | Nivel 1 | 90 | 0.0174375 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø | 0.00887 | 0.0000105781 | Suministro hidrónico 1 | 19 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
940320 | Nivel 1 | 0.0174375 | 0.0110875 | 2.2 | Nivel 1 | 90 | 0.0174375 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø | 0.00887 | 0.0000105781 | Suministro hidrónico 1 | 19 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
940328 | Nivel 1 | 0.0174375 | 0.0110875 | 2.2 | Nivel 1 | 90 | 0.0174375 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø | 0.00887 | 0.0000105781 | Suministro hidrónico 3 | 19 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
940330 | Nivel 1 | 0.0174375 | 0.0110875 | 2.2 | Nivel 1 | 90 | 0.0174375 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø | 0.00887 | 0.0000105781 | Suministro hidrónico 3 | 19 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
940362 | Nivel 1 | 0.0174375 | 0.0110875 | 2.2 | Nivel 1 | 90 | 0.0174375 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø | 0.00887 | 0.0000105781 | Suministro hidrónico 1 | 19 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
940364 | Nivel 1 | 0.0174375 | 0.0110875 | 2.2 | Nivel 1 | 90 | 0.0174375 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø | 0.00887 | 0.0000105781 | Suministro hidrónico 1 | 19 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
940372 | Nivel 1 | 0.0174375 | 0.0110875 | 2.2 | Nivel 1 | 90 | 0.0174375 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø | 0.00887 | 0.0000105781 | Suministro hidrónico 3 | 19 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
940374 | Nivel 1 | 0.0174375 | 0.0110875 | 2.2 | Nivel 1 | 90 | 0.0174375 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø | 0.00887 | 0.0000105781 | Suministro hidrónico 3 | 19 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
940399 | Nivel 1 | 0.0174375 | 0.0110875 | 2.2 | Nivel 1 | 90 | 0.0174375 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø | 0.00887 | 0.0000105781 | Suministro hidrónico 1 | 19 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
940401 | Nivel 1 | 0.0174375 | 0.0110875 | 2.2 | Nivel 1 | 90 | 0.0174375 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø | 0.00887 | 0.0000105781 | Suministro hidrónico 1 | 19 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
940409 | Nivel 1 | 0.0174375 | 0.0110875 | 2.2 | Nivel 1 | 90 | 0.0174375 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø | 0.00887 | 0.0000105781 | Suministro hidrónico 3 | 19 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
940411 | Nivel 1 | 0.0174375 | 0.0110875 | 2.2 | Nivel 1 | 90 | 0.0174375 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø | 0.00887 | 0.0000105781 | Suministro hidrónico 3 | 19 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
940436 | Nivel 1 | 0.0174375 | 0.0110875 | 2.2 | Nivel 1 | 90 | 0.0174375 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø | 0.00887 | 0.0000105781 | Suministro hidrónico 1 | 19 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
940438 | Nivel 1 | 0.0174375 | 0.0110875 | 2.2 | Nivel 1 | 90 | 0.0174375 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø | 0.00887 | 0.0000105781 | Suministro hidrónico 1 | 19 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
940446 | Nivel 1 | 0.0174375 | 0.0110875 | 2.2 | Nivel 1 | 90 | 0.0174375 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø | 0.00887 | 0.0000105781 | Suministro hidrónico 3 | 19 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
940448 | Nivel 1 | 0.0174375 | 0.0110875 | 2.2 | Nivel 1 | 90 | 0.0174375 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø | 0.00887 | 0.0000105781 | Suministro hidrónico 3 | 19 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
940473 | Nivel 1 | 0.0174375 | 0.0110875 | 2.2 | Nivel 1 | 90 | 0.0174375 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø | 0.00887 | 0.0000105781 | Suministro hidrónico 1 | 19 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
940475 | Nivel 1 | 0.0174375 | 0.0110875 | 2.2 | Nivel 1 | 90 | 0.0174375 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø | 0.00887 | 0.0000105781 | Suministro hidrónico 1 | 19 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
940483 | Nivel 1 | 0.0174375 | 0.0110875 | 2.2 | Nivel 1 | 90 | 0.0174375 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø | 0.00887 | 0.0000105781 | Suministro hidrónico 3 | 19 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
940485 | Nivel 1 | 0.0174375 | 0.0110875 | 2.2 | Nivel 1 | 90 | 0.0174375 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø | 0.00887 | 0.0000105781 | Suministro hidrónico 3 | 19 mmø-19 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
945407 | Nivel 1 | 0.0206375 | 0.0142875 | 2.44 | Nivel 1 | 90 | 0.0206375 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø | 0.01143 | 0.0000207886 | Suministro hidrónico 4 | 25 mmø-25 mmø
945417 | Nivel 1 | 0.0206375 | 0.0142875 | 2.44 | Nivel 1 | 90 | 0.0206375 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø | 0.01143 | 0.0000207886 | Suministro hidrónico 4 | 25 mmø-25 mmø
945436 | Nivel 1 | 0.0206375 | 0.0142875 | 2.44 | Nivel 1 | 90 | 0.0206375 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø | 0.01143 | 0.0000207886 | Suministro hidrónico 4 | 25 mmø-25 mmø
945553 | Nivel 1 | 0.0206375 | 0.0142875 | 2.44 | Nivel 1 | 90 | 0.0206375 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø | 0.01143 | 0.0000207886 | Suministro hidrónico 4 | 25 mmø-25 mmø
945568 | Nivel 1 | 0.0206375 | 0.0142875 | 2.39221 | Nivel 1 | 90 | 0.0206375 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø | 0.01143 | 0.0000207886 | Suministro hidrónico 4 | 25 mmø-25 mmø
945610 | Nivel 1 | 0.0206375 | 0.0142875 | 2.44 | Nivel 1 | 90 | 0.0206375 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø | 0.01143 | 0.0000207886 | Suministro hidrónico 4 | 25 mmø-25 mmø
945612 | Nivel 1 | 0.0206375 | 0.0142875 | 2.39221 | Nivel 1 | 90 | 0.0206375 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø | 0.01143 | 0.0000207886 | Suministro hidrónico 4 | 25 mmø-25 mmø
945635 | Nivel 1 | 0.0206375 | 0.0142875 | 2.44 | Nivel 1 | 90 | 0.0206375 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø | 0.01143 | 0.0000207886 | Suministro hidrónico 1 | 25 mmø-25 mmø
945639 | Nivel 1 | 0.0206375 | 0.0142875 | 2.44 | Nivel 1 | 90 | 0.0206375 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø | 0.01143 | 0.0000207886 | Suministro hidrónico 1 | 25 mmø-25 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
945718 | Nivel 1 | 0.0206375 | 0.0142875 | 2.44 | Nivel 1 | 90 | 0.0206375 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø | 0.01143 | 0.0000207886 | Suministro hidrónico 1 | 25 mmø-25 mmø
945730 | Nivel 1 | 0.0206375 | 0.0142875 | 2.44 | Nivel 1 | 90 | 0.0206375 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø | 0.01143 | 0.0000207886 | Suministro hidrónico 1 | 25 mmø-25 mmø
945758 | Nivel 1 | 0.0206375 | 0.0142875 | 2.44 | Nivel 1 | 90 | 0.0206375 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø | 0.01143 | 0.0000207886 | Suministro hidrónico 1 | 25 mmø-25 mmø
953228 | Nivel 1 | 0.0206375 | 0.0142875 | 2.44 | Nivel 1 | 90 | 0.0206375 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø | 0.01143 | 0.0000207886 | Suministro hidrónico 3 | 25 mmø-25 mmø
953230 | Nivel 1 | 0.0206375 | 0.0142875 | 2.38637 | Nivel 1 | 90 | 0.0206375 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø | 0.01143 | 0.0000207886 | Suministro hidrónico 3 | 25 mmø-25 mmø
953288 | Nivel 1 | 0.0206375 | 0.0142875 | 2.38637 | Nivel 1 | 90 | 0.0206375 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø | 0.01143 | 0.0000207886 | Suministro hidrónico 3 | 25 mmø-25 mmø
953327 | Nivel 1 | 0.0206375 | 0.0142875 | 2.44 | Nivel 1 | 90 | 0.0206375 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø | 0.01143 | 0.0000207886 | Suministro hidrónico 3 | 25 mmø-25 mmø
953361 | Nivel 1 | 0.0206375 | 0.0142875 | 2.44 | Nivel 1 | 90 | 0.0206375 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø | 0.01143 | 0.0000207886 | Suministro hidrónico 3 | 25 mmø-25 mmø
953438 | Nivel 1 | 0.0206375 | 0.0142875 | 2.44 | Nivel 1 | 90 | 0.0206375 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø | 0.01143 | 0.0000207886 | Suministro hidrónico 1 | 25 mmø-25 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
953442 | Nivel 1 | 0.0206375 | 0.0142875 | 2.44 | Nivel 1 | 90 | 0.0206375 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø | 0.01143 | 0.0000207886 | Suministro hidrónico 1 | 25 mmø-25 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
953474 | Nivel 1 | 0.0206375 | 0.0142875 | 2.44 | Nivel 1 | 90 | 0.0206375 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø | 0.01143 | 0.0000207886 | Suministro hidrónico 3 | 25 mmø-25 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
953478 | Nivel 1 | 0.0206375 | 0.0142875 | 2.44 | Nivel 1 | 90 | 0.0206375 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø | 0.01143 | 0.0000207886 | Suministro hidrónico 3 | 25 mmø-25 mmø | Mechanical - Flow - Pressure Drop: 0 Pa
953699 | Nivel 1 | 0.0139375 | 0.0075875 | 3.48 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 1 | 12 mmø-12 mmø
953703 | Nivel 1 | 0.0139375 | 0.0075875 | 3.48 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 1 | 12 mmø-12 mmø
953718 | Nivel 1 | 0.0139375 | 0.0075875 | 3.45 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 3 | 12 mmø-12 mmø
953722 | Nivel 1 | 0.0139375 | 0.0075875 | 3.45 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 3 | 12 mmø-12 mmø
954064 | Nivel 1 | 0.0139375 | 0.0075875 | 3.48 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 4 | 12 mmø-12 mmø
954252 | Nivel 1 | 0.0139375 | 0.0075875 | 3.48 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 4 | 12 mmø-12 mmø
954262 | Nivel 1 | 0.0139375 | 0.0075875 | 3.48 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 4 | 12 mmø-12 mmø
954264 | Nivel 1 | 0.0139375 | 0.0075875 | 3.48 | Nivel 1 | 90 | 0.0139375 | 0.015175 | 0.012 | 0.006 | 0.012ø-0.012ø | 0.00607 | 0.00000395949 | Suministro hidrónico 4 | 12 mmø-12 mmø
955111 | Nivel 1 | 0.0174375 | 0.0110875 | 3.48 | Nivel 1 | 90 | 0.0174375 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø | 0.00887 | 0.0000105781 | Suministro hidrónico 4 | 19 mmø-19 mmø
956545 | Nivel 1 | 0.0206375 | 0.0142875 | -1.4948 | Nivel 1 | 90 | 0.0206375 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø | 0.01143 | 0.0000207886 | Suministro hidrónico 4 | 25 mmø-25 mmø
956552 | Nivel 1 | 0.0206375 | 0.0142875 | -1.49478 | Nivel 1 | 90 | 0.0206375 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø | 0.01143 | 0.0000207886 | Suministro hidrónico 3 | 25 mmø-25 mmø
956554 | Nivel 1 | 0.0206375 | 0.0142875 | -1.49479 | Nivel 1 | 90 | 0.0206375 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø | 0.01143 | 0.0000207886 | Suministro hidrónico 3 | 25 mmø-25 mmø
956557 | Nivel 1 | 0.0206375 | 0.0142875 | -1.4948 | Nivel 1 | 90 | 0.0206375 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø | 0.01143 | 0.0000207886 | Suministro hidrónico 1 | 25 mmø-25 mmø
956927 | Nivel 1 | 0.0206375 | 0.0142875 | -1.49479 | Nivel 1 | 90.0001 | 0.0206375 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø | 0.01143 | 0.0000207887 | Suministro hidrónico 4 | 25 mmø-25 mmø
956939 | Nivel 1 | 0.0206375 | 0.0142875 | 3.7427 | Nivel 1 | 90.0002 | 0.0206376 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø | 0.01143 | 0.0000207887 | Suministro hidrónico 4 | 25 mmø-25 mmø
956962 | Nivel 1 | 0.0206375 | 0.0142875 | -1.49479 | Nivel 1 | 90 | 0.0206375 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø | 0.01143 | 0.0000207886 | Suministro hidrónico 3 | 25 mmø-25 mmø
956996 | Nivel 1 | 0.0206375 | 0.0142875 | -1.49479 | Nivel 1 | 90.0001 | 0.0206375 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø | 0.01143 | 0.0000207887 | Suministro hidrónico 1 | 25 mmø-25 mmø
957192 | Nivel 1 | 0.0206375 | 0.0142875 | 3.48 | Nivel 1 | 90 | 0.0206375 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø | 0.01143 | 0.0000207886 | Suministro hidrónico 1 | 25 mmø-25 mmø
957242 | Nivel 1 | 0.0206375 | 0.0142875 | 3.72771 | Nivel 1 | 90.0001 | 0.0206375 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø | 0.01143 | 0.0000207887 | Suministro hidrónico 1 | 25 mmø-25 mmø
957247 | Nivel 1 | 0.0206375 | 0.0142875 | 3.7277 | Nivel 1 | 90.0001 | 0.0206375 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø | 0.01143 | 0.0000207887 | Suministro hidrónico 1 | 25 mmø-25 mmø
957270 | Nivel 1 | 0.0206375 | 0.0142875 | 3.45 | Nivel 1 | 90 | 0.0206375 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø | 0.01143 | 0.0000207886 | Suministro hidrónico 3 | 25 mmø-25 mmø
957280 | Nivel 1 | 0.0206375 | 0.0142875 | 3.74271 | Nivel 1 | 90.0001 | 0.0206375 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø | 0.01143 | 0.0000207887 | Suministro hidrónico 3 | 25 mmø-25 mmø
957285 | Nivel 1 | 0.0206375 | 0.0142875 | 3.7427 | Nivel 1 | 89.9999 | 0.0206375 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø | 0.01143 | 0.0000207886 | Suministro hidrónico 3 | 25 mmø-25 mmø
957306 | Nivel 1 | 0.0206375 | 0.0142875 | 3.74271 | Nivel 1 | 90.0001 | 0.0206375 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø | 0.01143 | 0.0000207887 | Suministro hidrónico 4 | 25 mmø-25 mmø
957311 | Nivel 1 | 0.0206375 | 0.0142875 | 3.48 | Nivel 1 | 90 | 0.0206375 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø | 0.01143 | 0.0000207886 | Suministro hidrónico 4 | 25 mmø-25 mmø
957350 | Nivel 1 | 0.0206375 | 0.0142875 | -0.411516 | Nivel 1 | 90 | 0.0206375 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø | 0.01143 | 0.0000207886 | Suministro hidrónico 4 | 25 mmø-25 mmø
957352 | Nivel 1 | 0.0206375 | 0.0142875 | -1.4948 | Nivel 1 | 89.9976 | 0.0206366 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø | 0.0114295 | 0.0000207881 | Suministro hidrónico 4 | 25 mmø-25 mmø
957357 | Nivel 1 | 0.0206375 | 0.0142875 | -1.4948 | Nivel 1 | 90 | 0.0206375 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø | 0.01143 | 0.0000207886 | Suministro hidrónico 4 | 25 mmø-25 mmø
957364 | Nivel 1 | 0.0206375 | 0.0142875 | -1.49478 | Nivel 1 | 89.9976 | 0.0206366 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø | 0.0114295 | 0.0000207881 | Suministro hidrónico 3 | 25 mmø-25 mmø
957366 | Nivel 1 | 0.0206375 | 0.0142875 | -0.411517 | Nivel 1 | 90 | 0.0206375 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø | 0.01143 | 0.0000207886 | Suministro hidrónico 3 | 25 mmø-25 mmø
957370 | Nivel 1 | 0.0206375 | 0.0142875 | -0.411517 | Nivel 1 | 90 | 0.0206375 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø | 0.01143 | 0.0000207886 | Suministro hidrónico 3 | 25 mmø-25 mmø
957378 | Nivel 1 | 0.0206375 | 0.0142875 | -0.411515 | Nivel 1 | 90 | 0.0206375 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø | 0.01143 | 0.0000207886 | Suministro hidrónico 1 | 25 mmø-25 mmø
957380 | Nivel 1 | 0.0206375 | 0.0142875 | -1.4948 | Nivel 1 | 89.9975 | 0.0206366 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø | 0.0114295 | 0.0000207881 | Suministro hidrónico 1 | 25 mmø-25 mmø
957385 | Nivel 1 | 0.0206375 | 0.0142875 | -1.4948 | Nivel 1 | 90 | 0.0206375 | 0.028575 | 0.025 | 0.0125 | 0.025ø-0.025ø | 0.01143 | 0.0000207886 | Suministro hidrónico 1 | 25 mmø-25 mmø

# IfcPipeFitting: M_Codo - Soldado - Genérico:Norma (2)
Type - Material: <Unnamed>
Type - Other - Category: Pipe Fittings; Family Name: M_Codo - Soldado - Genérico; Nombre de tabla de consulta: M_Elbow - Welded - Generic
Type - Constraints - Default Elevation: 0 m
Type - Identity Data - OmniClass Number: 23.60.30.11.14; OmniClass Title: Pipework Fittings; Type Name: Norma
Type - Mechanical - Loss Method: K Coefficient from Table; Connection Type: Generic; K Coefficient Table: Regular 45, 90 and 180 Elbow
Classification: D2022.0 (FEMAP58); Group: Suministro hidrónico 4
Pset_EnvironmentalImpactIndicators - Reference: M_Codo - Soldado - Genérico:Norma; sets with these values: 2
Other - Type: Norma; Centro a etiqueta de extremo: 0.032 m; Family: M_Codo - Soldado - Genérico; Family and Type: M_Codo - Soldado - Genérico: Norma; Radio central: 0.032 m; Radio exterior de unión: 0.0211 m; Type Id: 552762
Dimensions - Ángulo: 90 deg; Centro a extremo: 0.032 m; Diámetro exterior de unión: 0.0422 m; Diámetro nominal: 0.032 m; Maximum Size: 0.032 m; Minimum Size: 0.032 m; Radio nominal: 0.016 m; Size: 0.032ø-0.032ø; Tamaño de marca: 0.01688 m; Volume: 0.0000703026 m3
Graphics - Use Annotation Scale: yes
Mechanical - System Type: Suministro hidrónico; System Classification: Hydronic Supply; System Name: Suministro hidrónico 4
Phasing - Phase Created: Nueva construcción
Insulation - Insulation Thickness: 0 m; Overall Size: 32 mmø-32 mmø
AboveGround - AboveGround: yes
Name (M_Codo - Soldado - Genérico:Norma:...) | In | Level | Elevation from Level (m)
915528 | Nivel 1 | Nivel 1 | 3.48
921159 | Nivel 2 | Nivel 2 | -0.77

# IfcPipeFitting: M_Cruz - Genérica:Norma (10)
In: Nivel 1
Type - Material: <Unnamed>
Type - Other - Category: Pipe Fittings; Family Name: M_Cruz - Genérica; Nombre de tabla de consulta: M_Pipe Fitting - Generic
Type - Constraints - Default Elevation: 0 m
Type - Identity Data - OmniClass Number: 23.60.30.11.14; OmniClass Title: Pipework Fittings; Type Name: Norma
Type - Mechanical - Connection Type: Generic; Loss Method: Not Defined
Classification: D2022.0 (FEMAP58)
Pset_EnvironmentalImpactIndicators - Reference: M_Cruz - Genérica:Norma; sets with these values: 2
Other - Type: Norma; Ángulo 3: 90 deg; Ángulo 4: 90 deg; Ángulo 5: 90 deg; Centro a etiqueta de extremo: 0.0237875 m; Family: M_Cruz - Genérica; Family and Type: M_Cruz - Genérica: Norma; Radio exterior de unión: 0.0110875 m; Type Id: 132244
Constraints - Level: Nivel 1; Elevation from Level: 2.2 m
Dimensions - Ángulo 1: 90 deg; Ángulo 2: 90 deg; Centro a extremo: 0.0237875 m; Diámetro exterior de unión: 0.022175 m; Diámetro nominal: 0.019 m; Maximum Size: 0.019 m; Minimum Size: 0.019 m; Radio nominal: 0.0095 m; Size: 0.019ø-0.019ø-0.019ø-0.019ø; Tamaño de marca: 0.00887 m; Volume: 0.0000294768 m3
Graphics - Use Annotation Scale: yes
Mechanical - System Type: Suministro hidrónico; System Classification: Hydronic Supply
Phasing - Phase Created: Nueva construcción
Insulation - Insulation Thickness: 0 m; Overall Size: 19 mmø-19 mmø-19 mmø-19 mmø
AboveGround - AboveGround: yes
Name (M_Cruz - Genérica:Norma:...) | System Name = Group
940597 | Suministro hidrónico 1
940603 | Suministro hidrónico 1
940609 | Suministro hidrónico 1
940615 | Suministro hidrónico 1
940621 | Suministro hidrónico 1
940648 | Suministro hidrónico 3
940654 | Suministro hidrónico 3
940660 | Suministro hidrónico 3
940666 | Suministro hidrónico 3
940672 | Suministro hidrónico 3

# IfcPipeFitting: M_Te - Genérica:Norma (61)
In: Nivel 1
Type - Material: <Unnamed>
Type - Other - Category: Pipe Fittings; Family Name: M_Te - Genérica; Nombre de tabla de consulta: M_Pipe Fitting - Generic
Type - Constraints - Default Elevation: 0 m
Type - Identity Data - OmniClass Number: 23.60.30.11.14; OmniClass Title: Pipework Fittings; Type Name: Norma
Type - Mechanical - Loss Method: K Coefficient from Table; Connection Type: Generic; K Coefficient Table: Tee
Classification: D2022.0 (FEMAP58)
Pset_EnvironmentalImpactIndicators - Reference: M_Te - Genérica:Norma; sets with these values: 2
Other - Type: Norma; Ángulo 1: 90 deg; Family: M_Te - Genérica; Family and Type: M_Te - Genérica: Norma; Type Id: 130550
Constraints - Level: Nivel 1
Dimensions - Ángulo: 90 deg
Graphics - Use Annotation Scale: yes
Mechanical - System Type: Suministro hidrónico; System Classification: Hydronic Supply
Phasing - Phase Created: Nueva construcción
Insulation - Insulation Thickness: 0 m
AboveGround - AboveGround: yes
Name (M_Te - Genérica:Norma:...) | Centro a etiqueta de extremo (m) = Centro a extremo (m) | Radio exterior de unión (m) | Elevation from Level (m) | Diámetro exterior de unión (m) | Diámetro nominal (m) = Maximum Size (m) = Minimum Size (m) | Radio nominal (m) | Size | Tamaño de marca (m) | Volume (m3) | System Name = Group | Overall Size
910280 | 0.0237875 | 0.0110875 | 3.45 | 0.022175 | 0.019 | 0.0095 | 0.019ø-0.019ø-0.019ø | 0.00887 | 0.0000239249 | Suministro hidrónico 3 | 19 mmø-19 mmø-19 mmø
