Properties of the parts of a building model (IFC4), part 5 of 6

# IfcPipeSegment: Pipe Types:Aire Medicinal (197)
Name (Pipe Types:Aire Medicinal:...) | Classification | InvertElevation (m) = Lower End Bottom Elevation (m) = Lower End Invert Elevation (m) = Invert Elevation (m) = Lower End Bottom of Insulation Elevation (m) | Pset_FlowSegmentDiameter, Diameter (m) = Inside Diameter (m) = Outside Diameter (m) = Mechanical, Diameter (m) | Qto_PipeSegmentBaseQuantities, Length (m) = Dimensions, Length (m) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) = Area (m2) | End Middle Elevation (m) | Lower End Centerline Elevation (m) | Lower End Obvert Elevation (m) = Lower End Top Elevation (m) = Lower End Top of Insulation Elevation (m) | Middle Elevation (m) = Start Middle Elevation (m) | Slope | Upper End Bottom Elevation (m) = Upper End Invert Elevation (m) = Upper End Bottom of Insulation Elevation (m) | Upper End Centerline Elevation (m) | Upper End Obvert Elevation (m) = Upper End Top Elevation (m) = Upper End Top of Insulation Elevation (m) | Size | System Classification | System Name = Group | System Type | Relative Roughness | Section | Overall Size
910058 | D2022 (FEMAP58) | 3.4705 | 0.019 | 1.8051 | 0.000283486 | 0.107747 | 3.48 | 3.48 | 3.4895 | 3.48 | 0 | 3.4705 | 3.48 | 3.4895 | 0.019ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000133684 | 160 | 19 mmø
910066 | D2022 (FEMAP58) | 3.4705 | 0.019 | 3.37588 | 0.000283486 | 0.201507 | 3.48 | 3.48 | 3.4895 | 3.48 | 0 | 3.4705 | 3.48 | 3.4895 | 0.019ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000133684 | 150 | 19 mmø
910567 | D2022 (FEMAP58) | 3.474 | 0.012 | 4.25885 | 0.00011308 | 0.160555 | 3.48 | 3.48 | 3.486 | 3.48 | 0 | 3.474 | 3.48 | 3.486 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 157 | 12 mmø
910651 | D2022 (FEMAP58) | 3.474 | 0.012 | 1.30578 | 0.00011308 | 0.0492266 | 3.48 | 3.48 | 3.486 | 3.48 | 0 | 3.474 | 3.48 | 3.486 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 176 | 12 mmø
911545 | D2022 (FEMAP58) | 3.4705 | 0.019 | 0.262566 | 0.000283486 | 0.0156726 | 3.48 | 3.48 | 3.4895 | 3.48 | 0 | 3.4705 | 3.48 | 3.4895 | 0.019ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000133684 | 53 | 19 mmø
911724 | D2022 (FEMAP58) | 3.474 | 0.012 | 4.90339 | 0.00011308 | 0.184853 | 3.48 | 3.48 | 3.486 | 3.48 | 0 | 3.474 | 3.48 | 3.486 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 119 | 12 mmø
911773 | D2022 (FEMAP58) | 3.4705 | 0.019 | 2.48928 | 0.000283486 | 0.148586 | 3.48 | 3.48 | 3.4895 | 3.48 | 0 | 3.4705 | 3.48 | 3.4895 | 0.019ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000133684 | 86 | 19 mmø
911824 | D2022 (FEMAP58) | 3.474 | 0.012 | 0.90086 | 0.00011308 | 0.0339616 | 3.48 | 3.48 | 3.486 | 3.48 | 0 | 3.474 | 3.48 | 3.486 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 62 | 12 mmø
912064 | D2022 (FEMAP58) | 3.474 | 0.012 | 2.35518 | 0.00011308 | 0.088788 | 3.48 | 3.48 | 3.486 | 3.48 | 0 | 3.474 | 3.48 | 3.486 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 60 | 12 mmø
912072 | D2022 (FEMAP58) | 3.474 | 0.012 | 0.537158 | 0.00011308 | 0.0202504 | 3.48 | 3.48 | 3.486 | 3.48 | 0 | 3.474 | 3.48 | 3.486 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 62 | 12 mmø
912211 | D2022 (FEMAP58) | 3.474 | 0.012 | 0.89451 | 0.00011308 | 0.0337222 | 3.48 | 3.48 | 3.486 | 3.48 | 0 | 3.474 | 3.48 | 3.486 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 165 | 12 mmø
912269 | D2022 (FEMAP58) | 3.474 | 0.012 | 0.89451 | 0.00011308 | 0.0337222 | 3.48 | 3.48 | 3.486 | 3.48 | 0 | 3.474 | 3.48 | 3.486 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 164 | 12 mmø
912391 | D2022 (FEMAP58) | 3.474 | 0.012 | 4.8831 | 0.00011308 | 0.184088 | 3.48 | 3.48 | 3.486 | 3.48 | 0 | 3.474 | 3.48 | 3.486 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 130 | 12 mmø
912488 | D2022 (FEMAP58) | 3.474 | 0.012 | 0.914797 | 0.00011308 | 0.034487 | 3.48 | 3.48 | 3.486 | 3.48 | 0 | 3.474 | 3.48 | 3.486 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 66 | 12 mmø
912573 | D2022 (FEMAP58) | 3.474 | 0.012 | 1.45577 | 0.00011308 | 0.0548813 | 3.48 | 3.48 | 3.486 | 3.48 | 0 | 3.474 | 3.48 | 3.486 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 66 | 12 mmø
912592 | D2022 (FEMAP58) | 3.474 | 0.012 | 0.914797 | 0.00011308 | 0.034487 | 3.48 | 3.48 | 3.486 | 3.48 | 0 | 3.474 | 3.48 | 3.486 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 70 | 12 mmø
913005 | D2022 (FEMAP58) | 3.474 | 0.012 | 4.8831 | 0.00011308 | 0.184088 | 3.48 | 3.48 | 3.486 | 3.48 | 0 | 3.474 | 3.48 | 3.486 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 132 | 12 mmø
913029 | D2022 (FEMAP58) | 3.474 | 0.012 | 0.908447 | 0.00011308 | 0.0342477 | 3.48 | 3.48 | 3.486 | 3.48 | 0 | 3.474 | 3.48 | 3.486 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 166 | 12 mmø
913045 | D2022 (FEMAP58) | 3.474 | 0.012 | 0.914797 | 0.00011308 | 0.034487 | 3.48 | 3.48 | 3.486 | 3.48 | 0 | 3.474 | 3.48 | 3.486 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 90 | 12 mmø
913120 | D2022 (FEMAP58) | 3.474 | 0.012 | 0.631855 | 0.00011308 | 0.0238204 | 3.48 | 3.48 | 3.486 | 3.48 | 0 | 3.474 | 3.48 | 3.486 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 91 | 12 mmø
913122 | D2022 (FEMAP58) | 3.474 | 0.012 | 0.914797 | 0.00011308 | 0.034487 | 3.48 | 3.48 | 3.486 | 3.48 | 0 | 3.474 | 3.48 | 3.486 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 92 | 12 mmø
913630 | D2022 (FEMAP58) | 3.474 | 0.012 | 0.908447 | 0.00011308 | 0.0342477 | 3.48 | 3.48 | 3.486 | 3.48 | 0 | 3.474 | 3.48 | 3.486 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 167 | 12 mmø
913690 | D2022 (FEMAP58) | 3.474 | 0.012 | 1.087 | 0.00011308 | 0.0409788 | 3.48 | 3.48 | 3.486 | 3.48 | 0 | 3.474 | 3.48 | 3.486 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 133 | 12 mmø
913989 | D2022 (FEMAP58) | 3.474 | 0.012 | 0.505377 | 0.00011308 | 0.0190522 | 3.48 | 3.48 | 3.486 | 3.48 | 0 | 3.474 | 3.48 | 3.486 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 173 | 12 mmø
914316 | D2022 (FEMAP58) | 3.474 | 0.012 | 0.511727 | 0.00011308 | 0.0192916 | 3.48 | 3.48 | 3.486 | 3.48 | 0 | 3.474 | 3.48 | 3.486 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 101 | 12 mmø
914417 | D2022 (FEMAP58) | 3.474 | 0.012 | 5.21912 | 0.00011308 | 0.196756 | 3.48 | 3.48 | 3.486 | 3.48 | 0 | 3.474 | 3.48 | 3.486 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 171 | 12 mmø
914473 | D2022 (FEMAP58) | 3.4705 | 0.019 | 2.07208 | 0.000283486 | 0.123683 | 3.48 | 3.48 | 3.4895 | 3.48 | 0 | 3.4705 | 3.48 | 3.4895 | 0.019ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000133684 | 154 | 19 mmø
914673 | D2022 (FEMAP58) | 3.474 | 0.012 | 1.94434 | 0.00011308 | 0.0733 | 3.48 | 3.48 | 3.486 | 3.48 | 0 | 3.474 | 3.48 | 3.486 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 169 | 12 mmø
916031 | D2022 (FEMAP58) | 3.474 | 0.012 | 1.75943 | 0.00011308 | 0.0663288 | 3.48 | 3.48 | 3.486 | 3.48 | 0 | 3.474 | 3.48 | 3.486 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 98 | 12 mmø
916331 | D2022 (FEMAP58) | 3.4705 | 0.019 | 3.63646 | 0.000283486 | 0.217061 | 3.48 | 3.48 | 3.4895 | 3.48 | 0 | 3.4705 | 3.48 | 3.4895 | 0.019ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000133684 | 2 | 19 mmø
916460 | D2022 (FEMAP58) | 3.474 | 0.012 | 0.772672 | 0.00011308 | 0.029129 | 3.48 | 3.48 | 3.486 | 3.48 | 0 | 3.474 | 3.48 | 3.486 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 70 | 12 mmø
916464 | D2022 (FEMAP58) | 3.4705 | 0.019 | 1.92718 | 0.000283486 | 0.115034 | 3.48 | 3.48 | 3.4895 | 3.48 | 0 | 3.4705 | 3.48 | 3.4895 | 0.019ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000133684 | 57 | 19 mmø
916495 | D2022 (FEMAP58) | 3.4705 | 0.019 | 6.24536 | 0.000283486 | 0.372787 | 3.48 | 3.48 | 3.4895 | 3.48 | 0 | 3.4705 | 3.48 | 3.4895 | 0.019ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000133684 | 64 | 19 mmø
916777 | D2022 (FEMAP58) | 3.474 | 0.012 | 0.505377 | 0.00011308 | 0.0190522 | 3.48 | 3.48 | 3.486 | 3.48 | 0 | 3.474 | 3.48 | 3.486 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 172 | 12 mmø
916786 | D2022 (FEMAP58) | 3.474 | 0.012 | 1.54578 | 0.00011308 | 0.0582743 | 3.48 | 3.48 | 3.486 | 3.48 | 0 | 3.474 | 3.48 | 3.486 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 101 | 12 mmø
917203 | D2022 (FEMAP58) | 3.474 | 0.012 | 1.10641 | 0.00011308 | 0.0417107 | 3.48 | 3.48 | 3.486 | 3.48 | 0 | 3.474 | 3.48 | 3.486 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 39 | 12 mmø
917430 | D2022 (FEMAP58) | 3.4705 | 0.019 | 10.2262 | 0.000283486 | 0.610405 | 3.48 | 3.48 | 3.4895 | 3.48 | 0 | 3.4705 | 3.48 | 3.4895 | 0.019ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000133684 | 5 | 19 mmø
921300 | D2022 (FEMAP58) | 3.4675 | 0.025 | 5.15626 | 0.0004908 | 0.404971 | 3.48 | 3.48 | 3.4925 | 3.48 | 0 | 3.4675 | 3.48 | 3.4925 | 0.025ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.0001016 | 221 | 25 mmø
921325 | D2022 (FEMAP58) | 3.4675 | 0.025 | 19.834 | 0.0004908 | 1.55776 | 3.48 | 3.48 | 3.4925 | 3.48 | 0 | 3.4675 | 3.48 | 3.4925 | 0.025ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.0001016 | 152 | 25 mmø
921331 | D2022 (FEMAP58) | 3.4675 | 0.025 | 1.14285 | 0.0004908 | 0.0897592 | 3.48 | 3.48 | 3.4925 | 3.48 | 0 | 3.4675 | 3.48 | 3.4925 | 0.025ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.0001016 | 4 | 25 mmø
921577 | D2022 (FEMAP58) | 3.4675 | 0.025 | 4.90252 | 0.0004908 | 0.385043 | 3.48 | 3.48 | 3.4925 | 3.48 | 0 | 3.4675 | 3.48 | 3.4925 | 0.025ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.0001016 | 221 | 25 mmø
922176 | D2022 (FEMAP58) | -0.424015 | 0.025 | 9.80665 | 0.0004908 | 0.770213 | -0.411515 | -0.411515 | -0.399015 | -0.411515 | 0 | -0.424015 | -0.411515 | -0.399015 | 0.025ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.0001016 | 221 | 25 mmø
922678 | D2022 (FEMAP58) | -0.390877 | 0.025 | 2.81024 | 0.0004908 | 0.220716 | 2.41936 | -0.390877 | -0.390877 | -0.390877 |  | 2.41936 | 2.41936 | 2.41936 | 0.025ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.0001016 | 221 | 25 mmø
923004 | D2022 (FEMAP58) | 2.4275 | 0.025 | 1.99367 | 0.0004908 | 0.156583 | 2.44 | 2.44 | 2.4525 | 2.44 | 0 | 2.4275 | 2.44 | 2.4525 | 0.025ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.0001016 | 207 | 25 mmø
924728 | D2022 (FEMAP58) | 3.474 | 0.012 | 1.1216 | 0.00011308 | 0.0422832 | 3.48 | 3.48 | 3.486 | 3.48 | 0 | 3.474 | 3.48 | 3.486 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 40 | 12 mmø
927653 | D2022 (FEMAP58) | 3.4705 | 0.019 | 3.24424 | 0.000283486 | 0.193649 | 3.48 | 3.48 | 3.4895 | 3.48 | 0 | 3.4705 | 3.48 | 3.4895 | 0.019ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000133684 | 158 | 19 mmø
927871 | D2022 (FEMAP58) | 1.61744 | 0.019 | 1.84512 | 0.000283486 | 0.110136 | 1.61744 | 1.61744 | 1.61744 | 3.46256 |  | 3.46256 | 3.46256 | 3.46256 | 0.019ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000133684 | 150 | 19 mmø
927881 | D2022 (FEMAP58) | 1.5905 | 0.019 | 0.285399 | 0.000283486 | 0.0170356 | 1.6 | 1.6 | 1.6095 | 1.6 | 0 | 1.5905 | 1.6 | 1.6095 | 0.019ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000133684 | 160 | 19 mmø
927891 | D2022 (FEMAP58) | 1.61744 | 0.019 | 1.84513 | 0.000283486 | 0.110136 | 1.61744 | 1.61744 | 1.61744 | 3.46256 |  | 3.46256 | 3.46256 | 3.46256 | 0.019ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000133684 | 160 | 19 mmø
931635 | D2022 (FEMAP58) | 3.4705 | 0.019 | 0.737371 | 0.000283486 | 0.0440138 | 3.48 | 3.48 | 3.4895 | 3.48 | 0 | 3.4705 | 3.48 | 3.4895 | 0.019ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000133684 | 160 | 19 mmø
933078 | D2022 (FEMAP58) | 1.5905 | 0.019 | 0.179024 | 0.000283486 | 0.010686 | 1.6 | 1.6 | 1.6095 | 1.6 | 0 | 1.5905 | 1.6 | 1.6095 | 0.019ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000133684 | 150 | 19 mmø
933541 | D2022 (FEMAP58) | 1.61744 | 0.019 | 1.84513 | 0.000283486 | 0.110136 | 1.61744 | 1.61744 | 1.61744 | 3.46256 |  | 3.46256 | 3.46256 | 3.46256 | 0.019ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000133684 | 158 | 19 mmø
933549 | D2022 (FEMAP58) | 1.5905 | 0.019 | 0.273536 | 0.000283486 | 0.0163275 | 1.6 | 1.6 | 1.6095 | 1.6 | 0 | 1.5905 | 1.6 | 1.6095 | 0.019ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000133684 | 162 | 19 mmø
933559 | D2022 (FEMAP58) | 1.61744 | 0.019 | 1.84513 | 0.000283486 | 0.110136 | 1.61744 | 1.61744 | 1.61744 | 3.46256 |  | 3.46256 | 3.46256 | 3.46256 | 0.019ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000133684 | 162 | 19 mmø
933795 | D2022 (FEMAP58) | 1.5905 | 0.019 | 0.212734 | 0.000283486 | 0.0126982 | 1.6 | 1.6 | 1.6095 | 1.6 | 0 | 1.5905 | 1.6 | 1.6095 | 0.019ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000133684 | 158 | 19 mmø
936138 | D2022 (FEMAP58) | 1.64621 | 0.012 | 1.81985 | 0.00011308 | 0.0686068 | 3.46606 | 1.64621 | 1.64621 | 1.64621 |  | 3.46606 | 3.46606 | 3.46606 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 1 | 12 mmø
936242 | D2022 (FEMAP58) | 1.64621 | 0.012 | 1.81985 | 0.00011308 | 0.0686068 | 3.46606 | 1.64621 | 1.64621 | 1.64621 |  | 3.46606 | 3.46606 | 3.46606 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 62 | 12 mmø
936273 | D2022 (FEMAP58) | 1.64621 | 0.012 | 1.81985 | 0.00011308 | 0.0686068 | 3.46606 | 1.64621 | 1.64621 | 1.64621 |  | 3.46606 | 3.46606 | 3.46606 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 164 | 12 mmø
936301 | D2022 (FEMAP58) | 1.64621 | 0.012 | 1.81985 | 0.00011308 | 0.0686068 | 3.46606 | 1.64621 | 1.64621 | 1.64621 |  | 3.46606 | 3.46606 | 3.46606 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 165 | 12 mmø
936327 | D2022 (FEMAP58) | 1.64621 | 0.012 | 1.81985 | 0.00011308 | 0.0686068 | 3.46606 | 1.64621 | 1.64621 | 1.64621 |  | 3.46606 | 3.46606 | 3.46606 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 66 | 12 mmø
936353 | D2022 (FEMAP58) | 1.64621 | 0.012 | 1.81985 | 0.00011308 | 0.0686068 | 3.46606 | 1.64621 | 1.64621 | 1.64621 |  | 3.46606 | 3.46606 | 3.46606 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 70 | 12 mmø
936379 | D2022 (FEMAP58) | 1.64621 | 0.012 | 1.81985 | 0.00011308 | 0.0686068 | 3.46606 | 1.64621 | 1.64621 | 1.64621 |  | 3.46606 | 3.46606 | 3.46606 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 92 | 12 mmø
936407 | D2022 (FEMAP58) | 1.64621 | 0.012 | 1.81985 | 0.00011308 | 0.0686068 | 3.46606 | 1.64621 | 1.64621 | 1.64621 |  | 3.46606 | 3.46606 | 3.46606 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 166 | 12 mmø
936433 | D2022 (FEMAP58) | 1.64621 | 0.012 | 1.81985 | 0.00011308 | 0.0686068 | 3.46606 | 1.64621 | 1.64621 | 1.64621 |  | 3.46606 | 3.46606 | 3.46606 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 167 | 12 mmø
936461 | D2022 (FEMAP58) | 1.64621 | 0.012 | 1.81985 | 0.00011308 | 0.0686068 | 3.46606 | 1.64621 | 1.64621 | 1.64621 |  | 3.46606 | 3.46606 | 3.46606 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 90 | 12 mmø
936668 | D2022 (FEMAP58) | 3.474 | 0.012 | 0.12428 | 0.00011308 | 0.00468524 | 3.48 | 3.48 | 3.486 | 3.48 | 0 | 3.474 | 3.48 | 3.486 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 119 | 12 mmø
936846 | D2022 (FEMAP58) | 3.474 | 0.012 | 1.26578 | 0.00011308 | 0.0477186 | 3.48 | 3.48 | 3.486 | 3.48 | 0 | 3.474 | 3.48 | 3.486 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 92 | 12 mmø
936871 | D2022 (FEMAP58) | 3.474 | 0.012 | 0.507466 | 0.00011308 | 0.019131 | 3.48 | 3.48 | 3.486 | 3.48 | 0 | 3.474 | 3.48 | 3.486 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 90 | 12 mmø
937111 | D2022 (FEMAP58) | 1.64621 | 0.012 | 1.81985 | 0.00011308 | 0.0686068 | 3.46606 | 1.64621 | 1.64621 | 1.64621 |  | 3.46606 | 3.46606 | 3.46606 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 169 | 12 mmø
937118 | D2022 (FEMAP58) | 3.4705 | 0.019 | 1.16511 | 0.000283486 | 0.0695455 | 3.48 | 3.48 | 3.4895 | 3.48 | 0 | 3.4705 | 3.48 | 3.4895 | 0.019ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000133684 | 162 | 19 mmø
937199 | D2022 (FEMAP58) | 1.64621 | 0.012 | 1.81985 | 0.00011308 | 0.0686068 | 3.46606 | 1.64621 | 1.64621 | 1.64621 |  | 3.46606 | 3.46606 | 3.46606 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 171 | 12 mmø
937206 | D2022 (FEMAP58) | 3.4705 | 0.019 | 3.29588 | 0.000283486 | 0.196732 | 3.48 | 3.48 | 3.4895 | 3.48 | 0 | 3.4705 | 3.48 | 3.4895 | 0.019ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000133684 | 95 | 19 mmø
937282 | D2022 (FEMAP58) | 1.64621 | 0.012 | 1.81985 | 0.00011308 | 0.0686068 | 3.46606 | 1.64621 | 1.64621 | 1.64621 |  | 3.46606 | 3.46606 | 3.46606 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 173 | 12 mmø
937314 | D2022 (FEMAP58) | 1.64621 | 0.012 | 1.81985 | 0.00011308 | 0.0686068 | 3.46606 | 1.64621 | 1.64621 | 1.64621 |  | 3.46606 | 3.46606 | 3.46606 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 172 | 12 mmø
937340 | D2022 (FEMAP58) | 1.64621 | 0.012 | 1.81985 | 0.00011308 | 0.0686068 | 3.46606 | 1.64621 | 1.64621 | 1.64621 |  | 3.46606 | 3.46606 | 3.46606 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 101 | 12 mmø
937522 | D2022 (FEMAP58) | 3.474 | 0.012 | 0.603039 | 0.00011308 | 0.022734 | 3.48 | 3.48 | 3.486 | 3.48 | 0 | 3.474 | 3.48 | 3.486 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 97 | 12 mmø
937550 | D2022 (FEMAP58) | 3.474 | 0.012 | 0.964777 | 0.00011308 | 0.0363712 | 3.48 | 3.48 | 3.486 | 3.48 | 0 | 3.474 | 3.48 | 3.486 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 39 | 12 mmø
937552 | D2022 (FEMAP58) | 1.64621 | 0.012 | 1.81985 | 0.00011308 | 0.0686068 | 3.46606 | 1.64621 | 1.64621 | 1.64621 |  | 3.46606 | 3.46606 | 3.46606 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 39 | 12 mmø
937588 | D2022 (FEMAP58) | 3.474 | 0.012 | 0.958427 | 0.00011308 | 0.0361318 | 3.48 | 3.48 | 3.486 | 3.48 | 0 | 3.474 | 3.48 | 3.486 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 175 | 12 mmø
937590 | D2022 (FEMAP58) | 1.64621 | 0.012 | 1.81985 | 0.00011308 | 0.0686068 | 3.46606 | 1.64621 | 1.64621 | 1.64621 |  | 3.46606 | 3.46606 | 3.46606 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 175 | 12 mmø
937616 | D2022 (FEMAP58) | 3.474 | 0.012 | 0.964777 | 0.00011308 | 0.0363712 | 3.48 | 3.48 | 3.486 | 3.48 | 0 | 3.474 | 3.48 | 3.486 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 174 | 12 mmø
937618 | D2022 (FEMAP58) | 1.64621 | 0.012 | 1.81985 | 0.00011308 | 0.0686068 | 3.46606 | 1.64621 | 1.64621 | 1.64621 |  | 3.46606 | 3.46606 | 3.46606 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 174 | 12 mmø
937642 | D2022 (FEMAP58) | 3.474 | 0.012 | 0.557893 | 0.00011308 | 0.0210321 | 3.48 | 3.48 | 3.486 | 3.48 | 0 | 3.474 | 3.48 | 3.486 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 176 | 12 mmø
937644 | D2022 (FEMAP58) | 1.64621 | 0.012 | 1.81985 | 0.00011308 | 0.0686068 | 3.46606 | 1.64621 | 1.64621 | 1.64621 |  | 3.46606 | 3.46606 | 3.46606 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 176 | 12 mmø
937682 | D2022 (FEMAP58) | 3.474 | 0.012 | 0.551543 | 0.00011308 | 0.0207927 | 3.48 | 3.48 | 3.486 | 3.48 | 0 | 3.474 | 3.48 | 3.486 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 177 | 12 mmø
937684 | D2022 (FEMAP58) | 1.64621 | 0.012 | 1.81985 | 0.00011308 | 0.0686068 | 3.46606 | 1.64621 | 1.64621 | 1.64621 |  | 3.46606 | 3.46606 | 3.46606 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 177 | 12 mmø
937708 | D2022 (FEMAP58) | 3.474 | 0.012 | 0.551543 | 0.00011308 | 0.0207927 | 3.48 | 3.48 | 3.486 | 3.48 | 0 | 3.474 | 3.48 | 3.486 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 179 | 12 mmø
937710 | D2022 (FEMAP58) | 1.64621 | 0.012 | 1.81985 | 0.00011308 | 0.0686068 | 3.46606 | 1.64621 | 1.64621 | 1.64621 |  | 3.46606 | 3.46606 | 3.46606 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 179 | 12 mmø
937736 | D2022 (FEMAP58) | 3.474 | 0.012 | 0.551543 | 0.00011308 | 0.0207927 | 3.48 | 3.48 | 3.486 | 3.48 | 0 | 3.474 | 3.48 | 3.486 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 181 | 12 mmø
937738 | D2022 (FEMAP58) | 1.64621 | 0.012 | 1.81985 | 0.00011308 | 0.0686068 | 3.46606 | 1.64621 | 1.64621 | 1.64621 |  | 3.46606 | 3.46606 | 3.46606 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 181 | 12 mmø
937784 | D2022 (FEMAP58) | 3.474 | 0.012 | 1.90907 | 0.00011308 | 0.0719704 | 3.48 | 3.48 | 3.486 | 3.48 | 0 | 3.474 | 3.48 | 3.486 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 174 | 12 mmø
937880 | D2022 (FEMAP58) | 3.474 | 0.012 | 1.05943 | 0.00011308 | 0.0399394 | 3.48 | 3.48 | 3.486 | 3.48 | 0 | 3.474 | 3.48 | 3.486 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 110 | 12 mmø
937888 | D2022 (FEMAP58) | 3.474 | 0.012 | 1.03943 | 0.00011308 | 0.0391854 | 3.48 | 3.48 | 3.486 | 3.48 | 0 | 3.474 | 3.48 | 3.486 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 178 | 12 mmø
937912 | D2022 (FEMAP58) | 3.474 | 0.012 | 1.27916 | 0.00011308 | 0.0482234 | 3.48 | 3.48 | 3.486 | 3.48 | 0 | 3.474 | 3.48 | 3.486 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 180 | 12 mmø
937942 | D2022 (FEMAP58) | 3.474 | 0.012 | 0.484872 | 0.00011308 | 0.0182792 | 3.48 | 3.48 | 3.486 | 3.48 | 0 | 3.474 | 3.48 | 3.486 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 185 | 12 mmø
937944 | D2022 (FEMAP58) | 1.64621 | 0.012 | 1.81985 | 0.00011308 | 0.0686068 | 3.46606 | 1.64621 | 1.64621 | 1.64621 |  | 3.46606 | 3.46606 | 3.46606 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 185 | 12 mmø
937991 | D2022 (FEMAP58) | 3.474 | 0.012 | 0.484872 | 0.00011308 | 0.0182792 | 3.48 | 3.48 | 3.486 | 3.48 | 0 | 3.474 | 3.48 | 3.486 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 183 | 12 mmø
937993 | D2022 (FEMAP58) | 1.64621 | 0.012 | 1.81985 | 0.00011308 | 0.0686068 | 3.46606 | 1.64621 | 1.64621 | 1.64621 |  | 3.46606 | 3.46606 | 3.46606 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 183 | 12 mmø
938015 | D2022 (FEMAP58) | 3.474 | 0.012 | 0.491222 | 0.00011308 | 0.0185186 | 3.48 | 3.48 | 3.486 | 3.48 | 0 | 3.474 | 3.48 | 3.486 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 6 | 12 mmø
938017 | D2022 (FEMAP58) | 1.64621 | 0.012 | 1.81985 | 0.00011308 | 0.0686068 | 3.46606 | 1.64621 | 1.64621 | 1.64621 |  | 3.46606 | 3.46606 | 3.46606 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 6 | 12 mmø
938046 | D2022 (FEMAP58) | 3.474 | 0.012 | 1.76578 | 0.00011308 | 0.0665681 | 3.48 | 3.48 | 3.486 | 3.48 | 0 | 3.474 | 3.48 | 3.486 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 6 | 12 mmø
938054 | D2022 (FEMAP58) | 3.474 | 0.012 | 1.29652 | 0.00011308 | 0.0488778 | 3.48 | 3.48 | 3.486 | 3.48 | 0 | 3.474 | 3.48 | 3.486 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 182 | 12 mmø
938110 | D2022 (FEMAP58) | 3.474 | 0.012 | 5.79339 | 0.00011308 | 0.218406 | 3.48 | 3.48 | 3.486 | 3.48 | 0 | 3.474 | 3.48 | 3.486 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 188 | 12 mmø
938112 | D2022 (FEMAP58) | 1.64621 | 0.012 | 1.81985 | 0.00011308 | 0.0686068 | 3.46606 | 1.64621 | 1.64621 | 1.64621 |  | 3.46606 | 3.46606 | 3.46606 | 0.012ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000211667 | 188 | 12 mmø
938293 | D2022 (FEMAP58) | 3.4705 | 0.019 | 4.27586 | 0.000283486 | 0.255227 | 3.48 | 3.48 | 3.4895 | 3.48 | 0 | 3.4705 | 3.48 | 3.4895 | 0.019ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000133684 | 186 | 19 mmø
940202 | D2022 (FEMAP58) | 1.65012 | 0.019 | 0.53244 | 0.000283486 | 0.0317815 | 2.18256 | 1.65012 | 1.65012 | 1.65012 |  | 2.18256 | 2.18256 | 2.18256 | 0.019ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000133684 | 213 | 19 mmø
940210 | D2022 (FEMAP58) | 1.65012 | 0.019 | 0.53244 | 0.000283486 | 0.0317815 | 2.18256 | 1.65012 | 1.65012 | 1.65012 |  | 2.18256 | 2.18256 | 2.18256 | 0.019ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000133684 | 10 | 19 mmø
940245 | D2022 (FEMAP58) | 1.65012 | 0.019 | 0.53244 | 0.000283486 | 0.0317815 | 2.18256 | 1.65012 | 1.65012 | 1.65012 |  | 2.18256 | 2.18256 | 2.18256 | 0.019ø | Hydronic Supply | Suministro hidrónico 3 | Suministro hidrónico | 0.000133684 | 2 | 19 mmø
940253 | D2022 (FEMAP58) | 1.65012 | 0.019 | 0.53244 | 0.000283486 | 0.0317815 | 2.18256 | 1.65012 | 1.65012 | 1.65012 |  | 2.18256 | 2.18256 | 2.18256 | 0.019ø | Hydronic Supply | Suministro hidrónico 3 | Suministro hidrónico | 0.000133684 | 10 | 19 mmø
940275 | D2022 (FEMAP58) | 2.1905 | 0.019 | 0.230395 | 0.000283486 | 0.0137523 | 2.2 | 2.2 | 2.2095 | 2.2 | 0 | 2.1905 | 2.2 | 2.2095 | 0.019ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000133684 | 12 | 19 mmø
940277 | D2022 (FEMAP58) | 1.65012 | 0.019 | 0.53244 | 0.000283486 | 0.0317815 | 2.18256 | 1.65012 | 1.65012 | 1.65012 |  | 2.18256 | 2.18256 | 2.18256 | 0.019ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000133684 | 12 | 19 mmø
940279 | D2022 (FEMAP58) | 1.65012 | 0.019 | 0.53244 | 0.000283486 | 0.0317815 | 2.18256 | 1.65012 | 1.65012 | 1.65012 |  | 2.18256 | 2.18256 | 2.18256 | 0.019ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000133684 | 14 | 19 mmø
940285 | D2022 (FEMAP58) | 2.1905 | 0.019 | 0.230395 | 0.000283486 | 0.0137523 | 2.2 | 2.2 | 2.2095 | 2.2 | 0 | 2.1905 | 2.2 | 2.2095 | 0.019ø | Hydronic Supply | Suministro hidrónico 3 | Suministro hidrónico | 0.000133684 | 12 | 19 mmø
940287 | D2022 (FEMAP58) | 1.65012 | 0.019 | 0.53244 | 0.000283486 | 0.0317815 | 2.18256 | 1.65012 | 1.65012 | 1.65012 |  | 2.18256 | 2.18256 | 2.18256 | 0.019ø | Hydronic Supply | Suministro hidrónico 3 | Suministro hidrónico | 0.000133684 | 12 | 19 mmø
940289 | D2022 (FEMAP58) | 1.65012 | 0.019 | 0.53244 | 0.000283486 | 0.0317815 | 2.18256 | 1.65012 | 1.65012 | 1.65012 |  | 2.18256 | 2.18256 | 2.18256 | 0.019ø | Hydronic Supply | Suministro hidrónico 3 | Suministro hidrónico | 0.000133684 | 14 | 19 mmø
940312 | D2022 (FEMAP58) | 2.1905 | 0.019 | 0.230395 | 0.000283486 | 0.0137523 | 2.2 | 2.2 | 2.2095 | 2.2 | 0 | 2.1905 | 2.2 | 2.2095 | 0.019ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000133684 | 16 | 19 mmø
940314 | D2022 (FEMAP58) | 1.65012 | 0.019 | 0.53244 | 0.000283486 | 0.0317815 | 2.18256 | 1.65012 | 1.65012 | 1.65012 |  | 2.18256 | 2.18256 | 2.18256 | 0.019ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000133684 | 16 | 19 mmø
940316 | D2022 (FEMAP58) | 1.65012 | 0.019 | 0.53244 | 0.000283486 | 0.0317815 | 2.18256 | 1.65012 | 1.65012 | 1.65012 |  | 2.18256 | 2.18256 | 2.18256 | 0.019ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000133684 | 18 | 19 mmø
940322 | D2022 (FEMAP58) | 2.1905 | 0.019 | 0.230395 | 0.000283486 | 0.0137523 | 2.2 | 2.2 | 2.2095 | 2.2 | 0 | 2.1905 | 2.2 | 2.2095 | 0.019ø | Hydronic Supply | Suministro hidrónico 3 | Suministro hidrónico | 0.000133684 | 211 | 19 mmø
940324 | D2022 (FEMAP58) | 1.65012 | 0.019 | 0.53244 | 0.000283486 | 0.0317815 | 2.18256 | 1.65012 | 1.65012 | 1.65012 |  | 2.18256 | 2.18256 | 2.18256 | 0.019ø | Hydronic Supply | Suministro hidrónico 3 | Suministro hidrónico | 0.000133684 | 211 | 19 mmø
940326 | D2022 (FEMAP58) | 1.65012 | 0.019 | 0.53244 | 0.000283486 | 0.0317815 | 2.18256 | 1.65012 | 1.65012 | 1.65012 |  | 2.18256 | 2.18256 | 2.18256 | 0.019ø | Hydronic Supply | Suministro hidrónico 3 | Suministro hidrónico | 0.000133684 | 213 | 19 mmø
940356 | D2022 (FEMAP58) | 2.1905 | 0.019 | 0.230395 | 0.000283486 | 0.0137523 | 2.2 | 2.2 | 2.2095 | 2.2 | 0 | 2.1905 | 2.2 | 2.2095 | 0.019ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000133684 | 20 | 19 mmø
940358 | D2022 (FEMAP58) | 1.65012 | 0.019 | 0.53244 | 0.000283486 | 0.0317815 | 2.18256 | 1.65012 | 1.65012 | 1.65012 |  | 2.18256 | 2.18256 | 2.18256 | 0.019ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000133684 | 20 | 19 mmø
940360 | D2022 (FEMAP58) | 1.65012 | 0.019 | 0.53244 | 0.000283486 | 0.0317815 | 2.18256 | 1.65012 | 1.65012 | 1.65012 |  | 2.18256 | 2.18256 | 2.18256 | 0.019ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000133684 | 22 | 19 mmø
940366 | D2022 (FEMAP58) | 2.1905 | 0.019 | 0.230395 | 0.000283486 | 0.0137523 | 2.2 | 2.2 | 2.2095 | 2.2 | 0 | 2.1905 | 2.2 | 2.2095 | 0.019ø | Hydronic Supply | Suministro hidrónico 3 | Suministro hidrónico | 0.000133684 | 215 | 19 mmø
940368 | D2022 (FEMAP58) | 1.65012 | 0.019 | 0.53244 | 0.000283486 | 0.0317815 | 2.18256 | 1.65012 | 1.65012 | 1.65012 |  | 2.18256 | 2.18256 | 2.18256 | 0.019ø | Hydronic Supply | Suministro hidrónico 3 | Suministro hidrónico | 0.000133684 | 215 | 19 mmø
940370 | D2022 (FEMAP58) | 1.65012 | 0.019 | 0.53244 | 0.000283486 | 0.0317815 | 2.18256 | 1.65012 | 1.65012 | 1.65012 |  | 2.18256 | 2.18256 | 2.18256 | 0.019ø | Hydronic Supply | Suministro hidrónico 3 | Suministro hidrónico | 0.000133684 | 217 | 19 mmø
940393 | D2022 (FEMAP58) | 2.1905 | 0.019 | 0.230395 | 0.000283486 | 0.0137523 | 2.2 | 2.2 | 2.2095 | 2.2 | 0 | 2.1905 | 2.2 | 2.2095 | 0.019ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000133684 | 24 | 19 mmø
940395 | D2022 (FEMAP58) | 1.65012 | 0.019 | 0.53244 | 0.000283486 | 0.0317815 | 2.18256 | 1.65012 | 1.65012 | 1.65012 |  | 2.18256 | 2.18256 | 2.18256 | 0.019ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000133684 | 24 | 19 mmø
940397 | D2022 (FEMAP58) | 1.65012 | 0.019 | 0.53244 | 0.000283486 | 0.0317815 | 2.18256 | 1.65012 | 1.65012 | 1.65012 |  | 2.18256 | 2.18256 | 2.18256 | 0.019ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000133684 | 26 | 19 mmø
940403 | D2022 (FEMAP58) | 2.1905 | 0.019 | 0.230395 | 0.000283486 | 0.0137523 | 2.2 | 2.2 | 2.2095 | 2.2 | 0 | 2.1905 | 2.2 | 2.2095 | 0.019ø | Hydronic Supply | Suministro hidrónico 3 | Suministro hidrónico | 0.000133684 | 24 | 19 mmø
940405 | D2022 (FEMAP58) | 1.65012 | 0.019 | 0.53244 | 0.000283486 | 0.0317815 | 2.18256 | 1.65012 | 1.65012 | 1.65012 |  | 2.18256 | 2.18256 | 2.18256 | 0.019ø | Hydronic Supply | Suministro hidrónico 3 | Suministro hidrónico | 0.000133684 | 24 | 19 mmø
940407 | D2022 (FEMAP58) | 1.65012 | 0.019 | 0.53244 | 0.000283486 | 0.0317815 | 2.18256 | 1.65012 | 1.65012 | 1.65012 |  | 2.18256 | 2.18256 | 2.18256 | 0.019ø | Hydronic Supply | Suministro hidrónico 3 | Suministro hidrónico | 0.000133684 | 26 | 19 mmø
940430 | D2022 (FEMAP58) | 2.1905 | 0.019 | 0.230395 | 0.000283486 | 0.0137523 | 2.2 | 2.2 | 2.2095 | 2.2 | 0 | 2.1905 | 2.2 | 2.2095 | 0.019ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000133684 | 28 | 19 mmø
940432 | D2022 (FEMAP58) | 1.65012 | 0.019 | 0.53244 | 0.000283486 | 0.0317815 | 2.18256 | 1.65012 | 1.65012 | 1.65012 |  | 2.18256 | 2.18256 | 2.18256 | 0.019ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000133684 | 28 | 19 mmø
940434 | D2022 (FEMAP58) | 1.65012 | 0.019 | 0.53244 | 0.000283486 | 0.0317815 | 2.18256 | 1.65012 | 1.65012 | 1.65012 |  | 2.18256 | 2.18256 | 2.18256 | 0.019ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000133684 | 30 | 19 mmø
940440 | D2022 (FEMAP58) | 2.1905 | 0.019 | 0.230395 | 0.000283486 | 0.0137523 | 2.2 | 2.2 | 2.2095 | 2.2 | 0 | 2.1905 | 2.2 | 2.2095 | 0.019ø | Hydronic Supply | Suministro hidrónico 3 | Suministro hidrónico | 0.000133684 | 28 | 19 mmø
940442 | D2022 (FEMAP58) | 1.65012 | 0.019 | 0.53244 | 0.000283486 | 0.0317815 | 2.18256 | 1.65012 | 1.65012 | 1.65012 |  | 2.18256 | 2.18256 | 2.18256 | 0.019ø | Hydronic Supply | Suministro hidrónico 3 | Suministro hidrónico | 0.000133684 | 28 | 19 mmø
940444 | D2022 (FEMAP58) | 1.65012 | 0.019 | 0.53244 | 0.000283486 | 0.0317815 | 2.18256 | 1.65012 | 1.65012 | 1.65012 |  | 2.18256 | 2.18256 | 2.18256 | 0.019ø | Hydronic Supply | Suministro hidrónico 3 | Suministro hidrónico | 0.000133684 | 222 | 19 mmø
940467 | D2022 (FEMAP58) | 2.1905 | 0.019 | 0.230395 | 0.000283486 | 0.0137523 | 2.2 | 2.2 | 2.2095 | 2.2 | 0 | 2.1905 | 2.2 | 2.2095 | 0.019ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000133684 | 32 | 19 mmø
940469 | D2022 (FEMAP58) | 1.65012 | 0.019 | 0.53244 | 0.000283486 | 0.0317815 | 2.18256 | 1.65012 | 1.65012 | 1.65012 |  | 2.18256 | 2.18256 | 2.18256 | 0.019ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000133684 | 32 | 19 mmø
940471 | D2022 (FEMAP58) | 1.65012 | 0.019 | 0.53244 | 0.000283486 | 0.0317815 | 2.18256 | 1.65012 | 1.65012 | 1.65012 |  | 2.18256 | 2.18256 | 2.18256 | 0.019ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000133684 | 34 | 19 mmø
940477 | D2022 (FEMAP58) | 2.1905 | 0.019 | 0.230395 | 0.000283486 | 0.0137523 | 2.2 | 2.2 | 2.2095 | 2.2 | 0 | 2.1905 | 2.2 | 2.2095 | 0.019ø | Hydronic Supply | Suministro hidrónico 3 | Suministro hidrónico | 0.000133684 | 32 | 19 mmø
940479 | D2022 (FEMAP58) | 1.65012 | 0.019 | 0.53244 | 0.000283486 | 0.0317815 | 2.18256 | 1.65012 | 1.65012 | 1.65012 |  | 2.18256 | 2.18256 | 2.18256 | 0.019ø | Hydronic Supply | Suministro hidrónico 3 | Suministro hidrónico | 0.000133684 | 32 | 19 mmø
940481 | D2022 (FEMAP58) | 1.65012 | 0.019 | 0.53244 | 0.000283486 | 0.0317815 | 2.18256 | 1.65012 | 1.65012 | 1.65012 |  | 2.18256 | 2.18256 | 2.18256 | 0.019ø | Hydronic Supply | Suministro hidrónico 3 | Suministro hidrónico | 0.000133684 | 221 | 19 mmø
940565 | D2022 (FEMAP58) | 2.1905 | 0.019 | 0.352425 | 0.000283486 | 0.0210363 | 2.2 | 2.2 | 2.2095 | 2.2 | 0 | 2.1905 | 2.2 | 2.2095 | 0.019ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000133684 | 3 | 19 mmø
940578 | D2022 (FEMAP58) | 2.1905 | 0.019 | 0.230395 | 0.000283486 | 0.0137523 | 2.2 | 2.2 | 2.2095 | 2.2 | 0 | 2.1905 | 2.2 | 2.2095 | 0.019ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000133684 | 213 | 19 mmø
940582 | D2022 (FEMAP58) | 2.1905 | 0.019 | 0.230395 | 0.000283486 | 0.0137523 | 2.2 | 2.2 | 2.2095 | 2.2 | 0 | 2.1905 | 2.2 | 2.2095 | 0.019ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000133684 | 34 | 19 mmø
940588 | D2022 (FEMAP58) | 2.1905 | 0.019 | 0.230395 | 0.000283486 | 0.0137523 | 2.2 | 2.2 | 2.2095 | 2.2 | 0 | 2.1905 | 2.2 | 2.2095 | 0.019ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000133684 | 10 | 19 mmø
940593 | D2022 (FEMAP58) | 2.1905 | 0.019 | 0.321689 | 0.000283486 | 0.0192017 | 2.2 | 2.2 | 2.2095 | 2.2 | 0 | 2.1905 | 2.2 | 2.2095 | 0.019ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000133684 | 8 | 19 mmø
940595 | D2022 (FEMAP58) | 2.1905 | 0.019 | 0.230395 | 0.000283486 | 0.0137523 | 2.2 | 2.2 | 2.2095 | 2.2 | 0 | 2.1905 | 2.2 | 2.2095 | 0.019ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000133684 | 30 | 19 mmø
940599 | D2022 (FEMAP58) | 2.1905 | 0.019 | 0.321689 | 0.000283486 | 0.0192017 | 2.2 | 2.2 | 2.2095 | 2.2 | 0 | 2.1905 | 2.2 | 2.2095 | 0.019ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000133684 | 7 | 19 mmø
940601 | D2022 (FEMAP58) | 2.1905 | 0.019 | 0.230395 | 0.000283486 | 0.0137523 | 2.2 | 2.2 | 2.2095 | 2.2 | 0 | 2.1905 | 2.2 | 2.2095 | 0.019ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000133684 | 26 | 19 mmø
940605 | D2022 (FEMAP58) | 2.1905 | 0.019 | 0.130422 | 0.000283486 | 0.00778493 | 2.2 | 2.2 | 2.2095 | 2.2 | 0 | 2.1905 | 2.2 | 2.2095 | 0.019ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000133684 | 210 | 19 mmø
940607 | D2022 (FEMAP58) | 2.1905 | 0.019 | 0.230395 | 0.000283486 | 0.0137523 | 2.2 | 2.2 | 2.2095 | 2.2 | 0 | 2.1905 | 2.2 | 2.2095 | 0.019ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000133684 | 22 | 19 mmø
940611 | D2022 (FEMAP58) | 2.1905 | 0.019 | 0.321689 | 0.000283486 | 0.0192017 | 2.2 | 2.2 | 2.2095 | 2.2 | 0 | 2.1905 | 2.2 | 2.2095 | 0.019ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000133684 | 211 | 19 mmø
940613 | D2022 (FEMAP58) | 2.1905 | 0.019 | 0.230395 | 0.000283486 | 0.0137523 | 2.2 | 2.2 | 2.2095 | 2.2 | 0 | 2.1905 | 2.2 | 2.2095 | 0.019ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000133684 | 18 | 19 mmø
940617 | D2022 (FEMAP58) | 2.1905 | 0.019 | 0.321689 | 0.000283486 | 0.0192017 | 2.2 | 2.2 | 2.2095 | 2.2 | 0 | 2.1905 | 2.2 | 2.2095 | 0.019ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000133684 | 212 | 19 mmø
940619 | D2022 (FEMAP58) | 2.1905 | 0.019 | 0.230395 | 0.000283486 | 0.0137523 | 2.2 | 2.2 | 2.2095 | 2.2 | 0 | 2.1905 | 2.2 | 2.2095 | 0.019ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000133684 | 14 | 19 mmø
940624 | D2022 (FEMAP58) | 2.1905 | 0.019 | 0.352425 | 0.000283486 | 0.0210363 | 2.2 | 2.2 | 2.2095 | 2.2 | 0 | 2.1905 | 2.2 | 2.2095 | 0.019ø | Hydronic Supply | Suministro hidrónico 3 | Suministro hidrónico | 0.000133684 | 3 | 19 mmø
940633 | D2022 (FEMAP58) | 2.1905 | 0.019 | 0.230395 | 0.000283486 | 0.0137523 | 2.2 | 2.2 | 2.2095 | 2.2 | 0 | 2.1905 | 2.2 | 2.2095 | 0.019ø | Hydronic Supply | Suministro hidrónico 3 | Suministro hidrónico | 0.000133684 | 2 | 19 mmø
940637 | D2022 (FEMAP58) | 2.1905 | 0.019 | 0.230395 | 0.000283486 | 0.0137523 | 2.2 | 2.2 | 2.2095 | 2.2 | 0 | 2.1905 | 2.2 | 2.2095 | 0.019ø | Hydronic Supply | Suministro hidrónico 3 | Suministro hidrónico | 0.000133684 | 221 | 19 mmø
940641 | D2022 (FEMAP58) | 2.1905 | 0.019 | 0.230395 | 0.000283486 | 0.0137523 | 2.2 | 2.2 | 2.2095 | 2.2 | 0 | 2.1905 | 2.2 | 2.2095 | 0.019ø | Hydronic Supply | Suministro hidrónico 3 | Suministro hidrónico | 0.000133684 | 10 | 19 mmø
940644 | D2022 (FEMAP58) | 2.1905 | 0.019 | 0.321689 | 0.000283486 | 0.0192017 | 2.2 | 2.2 | 2.2095 | 2.2 | 0 | 2.1905 | 2.2 | 2.2095 | 0.019ø | Hydronic Supply | Suministro hidrónico 3 | Suministro hidrónico | 0.000133684 | 8 | 19 mmø
940646 | D2022 (FEMAP58) | 2.1905 | 0.019 | 0.230395 | 0.000283486 | 0.0137523 | 2.2 | 2.2 | 2.2095 | 2.2 | 0 | 2.1905 | 2.2 | 2.2095 | 0.019ø | Hydronic Supply | Suministro hidrónico 3 | Suministro hidrónico | 0.000133684 | 222 | 19 mmø
940650 | D2022 (FEMAP58) | 2.1905 | 0.019 | 0.321689 | 0.000283486 | 0.0192017 | 2.2 | 2.2 | 2.2095 | 2.2 | 0 | 2.1905 | 2.2 | 2.2095 | 0.019ø | Hydronic Supply | Suministro hidrónico 3 | Suministro hidrónico | 0.000133684 | 7 | 19 mmø
940652 | D2022 (FEMAP58) | 2.1905 | 0.019 | 0.230395 | 0.000283486 | 0.0137523 | 2.2 | 2.2 | 2.2095 | 2.2 | 0 | 2.1905 | 2.2 | 2.2095 | 0.019ø | Hydronic Supply | Suministro hidrónico 3 | Suministro hidrónico | 0.000133684 | 26 | 19 mmø
940656 | D2022 (FEMAP58) | 2.1905 | 0.019 | 0.127922 | 0.000283486 | 0.0076357 | 2.2 | 2.2 | 2.2095 | 2.2 | 0 | 2.1905 | 2.2 | 2.2095 | 0.019ø | Hydronic Supply | Suministro hidrónico 3 | Suministro hidrónico | 0.000133684 | 6 | 19 mmø
940658 | D2022 (FEMAP58) | 2.1905 | 0.019 | 0.230395 | 0.000283486 | 0.0137523 | 2.2 | 2.2 | 2.2095 | 2.2 | 0 | 2.1905 | 2.2 | 2.2095 | 0.019ø | Hydronic Supply | Suministro hidrónico 3 | Suministro hidrónico | 0.000133684 | 217 | 19 mmø
940662 | D2022 (FEMAP58) | 2.1905 | 0.019 | 0.321689 | 0.000283486 | 0.0192017 | 2.2 | 2.2 | 2.2095 | 2.2 | 0 | 2.1905 | 2.2 | 2.2095 | 0.019ø | Hydronic Supply | Suministro hidrónico 3 | Suministro hidrónico | 0.000133684 | 5 | 19 mmø
940664 | D2022 (FEMAP58) | 2.1905 | 0.019 | 0.230395 | 0.000283486 | 0.0137523 | 2.2 | 2.2 | 2.2095 | 2.2 | 0 | 2.1905 | 2.2 | 2.2095 | 0.019ø | Hydronic Supply | Suministro hidrónico 3 | Suministro hidrónico | 0.000133684 | 213 | 19 mmø
940668 | D2022 (FEMAP58) | 2.1905 | 0.019 | 0.321689 | 0.000283486 | 0.0192017 | 2.2 | 2.2 | 2.2095 | 2.2 | 0 | 2.1905 | 2.2 | 2.2095 | 0.019ø | Hydronic Supply | Suministro hidrónico 3 | Suministro hidrónico | 0.000133684 | 4 | 19 mmø
940670 | D2022 (FEMAP58) | 2.1905 | 0.019 | 0.230395 | 0.000283486 | 0.0137523 | 2.2 | 2.2 | 2.2095 | 2.2 | 0 | 2.1905 | 2.2 | 2.2095 | 0.019ø | Hydronic Supply | Suministro hidrónico 3 | Suministro hidrónico | 0.000133684 | 14 | 19 mmø
945386 | D2022 (FEMAP58) | 2.4275 | 0.025 | 6.65224 | 0.0004908 | 0.522466 | 2.44 | 2.44 | 2.4525 | 2.44 | 0 | 2.4275 | 2.44 | 2.4525 | 0.025ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.0001016 | 207 | 25 mmø
945694 | D2022 (FEMAP58) | 2.4275 | 0.025 | 0.635925 | 0.0004908 | 0.0499454 | 2.44 | 2.44 | 2.4525 | 2.44 | 0 | 2.4275 | 2.44 | 2.4525 | 0.025ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.0001016 | 221 | 25 mmø
945704 | D2022 (FEMAP58) | 2.4275 | 0.025 | 0.991687 | 0.0004908 | 0.0778869 | 2.44 | 2.44 | 2.4525 | 2.44 | 0 | 2.4275 | 2.44 | 2.4525 | 0.025ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.0001016 | 208 | 25 mmø
945712 | D2022 (FEMAP58) | 2.4275 | 0.025 | 0.318725 | 0.0004908 | 0.0250326 | 2.44 | 2.44 | 2.4525 | 2.44 | 0 | 2.4275 | 2.44 | 2.4525 | 0.025ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.0001016 | 208 | 25 mmø
945720 | D2022 (FEMAP58) | 2.4275 | 0.025 | 1.21873 | 0.0004908 | 0.0957184 | 2.44 | 2.44 | 2.4525 | 2.44 | 0 | 2.4275 | 2.44 | 2.4525 | 0.025ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.0001016 | 208 | 25 mmø
945755 | D2022 (FEMAP58) | 0.7 | 0.025 | 1.71936 | 0.0004908 | 0.135038 | 0.7 | 0.7 | 0.7 | 2.41936 |  | 2.41936 | 2.41936 | 2.41936 | 0.025ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.0001016 | 208 | 25 mmø
953136 | D2021 (FEMAP58) | 0.2423 | 0.025 | 0.606506 | 0.0004908 | 0.0476349 | 0.2548 | 0.2548 | 0.2673 | 0.2548 | 0 | 0.2423 | 0.2548 | 0.2673 | 0.025ø | Domestic Cold Water | Agua fría doméstica 1 | Agua fría doméstica | 0.0001016 | 2 | 25 mmø | Mechanical - Flow - Fixture Units: 0
953409 | D2022 (FEMAP58) | 2.4275 | 0.025 | 0.775553 | 0.0004908 | 0.0609118 | 2.44 | 2.44 | 2.4525 | 2.44 | 0 | 2.4275 | 2.44 | 2.4525 | 0.025ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.0001016 | 207 | 25 mmø
953425 | D2022 (FEMAP58) | 2.22699 | 0.025 | 0.192375 | 0.0004908 | 0.0151091 | 2.41936 | 2.22699 | 2.22699 | 2.22699 |  | 2.41936 | 2.41936 | 2.41936 | 0.025ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.0001016 | 207 | 25 mmø
953428 | D2022 (FEMAP58) | 2.1905 | 0.019 | 0.123005 | 0.000283486 | 0.00734219 | 2.2 | 2.2 | 2.2095 | 2.2 | 0 | 2.1905 | 2.2 | 2.2095 | 0.019ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.000133684 | 216 | 19 mmø
953465 | D2022 (FEMAP58) | 2.1905 | 0.019 | 0.125505 | 0.000283486 | 0.00749141 | 2.2 | 2.2 | 2.2095 | 2.2 | 0 | 2.1905 | 2.2 | 2.2095 | 0.019ø | Hydronic Supply | Suministro hidrónico 3 | Suministro hidrónico | 0.000133684 | 220 | 19 mmø
956506 | D2022 (FEMAP58) | -1.5073 | 0.025 | 0.118773 | 0.0004908 | 0.00932844 | -1.4948 | -1.4948 | -1.4823 | -1.4948 | 0 | -1.5073 | -1.4948 | -1.4823 | 0.025ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.0001016 | 221 | 25 mmø
956516 | D2022 (FEMAP58) | -1.5073 | 0.025 | 0.210942 | 0.0004908 | 0.0165674 | -1.4948 | -1.4948 | -1.4823 | -1.4948 | 0 | -1.5073 | -1.4948 | -1.4823 | 0.025ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.0001016 | 221 | 25 mmø
956646 | D2022 (FEMAP58) | -1.5073 | 0.025 | 12.8149 | 0.000490782 | 1.00648 | -1.49479 | -1.4948 | -1.4823 | -1.4948 | 0 | -1.50729 | -1.49479 | -1.48229 | 0.025ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.0001016 | 221 | 25 mmø
956890 | D2022 (FEMAP58) | 3.7152 | 0.025 | 1.56903 | 0.0004908 | 0.123231 | 3.7277 | 3.7277 | 3.7402 | 3.72771 | 0 | 3.71521 | 3.72771 | 3.74021 | 0.025ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.0001016 | 221 | 25 mmø
956994 | D2022 (FEMAP58) | -1.47415 | 0.025 | 5.18121 | 0.0004908 | 0.406932 | 3.70707 | -1.47415 | -1.47415 | -1.47415 |  | 3.70707 | 3.70707 | 3.70707 | 0.025ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.0001016 | 221 | 25 mmø
957155 | D2022 (FEMAP58) | 3.50064 | 0.025 | 0.206431 | 0.0004908 | 0.016213 | 3.70707 | 3.50064 | 3.50064 | 3.50064 |  | 3.70707 | 3.70707 | 3.70707 | 0.025ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.0001016 | 221 | 25 mmø
957376 | D2022 (FEMAP58) | -1.47416 | 0.025 | 1.04201 | 0.0004908 | 0.0818391 | -1.47416 | -1.47416 | -1.47416 | -0.432152 |  | -0.432152 | -0.432152 | -0.432152 | 0.025ø | Hydronic Supply | Suministro hidrónico 1 | Suministro hidrónico | 0.0001016 | 221 | 25 mmø

# IfcPipeSegment: Pipe Types:Oxigeno (132)
In: Nivel 1
Type - Other - Category: Pipes; Family Name: Pipe Types
Type - Identity Data - Type Name: Oxigeno
Classification: D2022 (FEMAP58); Material: Cobre; Group: Suministro hidrónico 3
Pset_EnvironmentalImpactIndicators - Reference: Pipe Types:Oxigeno; sets with these values: 2
Other - Family: Pipe Types; Family and Type: Pipe Types: Oxigeno; Type: Oxigeno; Type Id: 558557
Constraints - Horizontal Justification: Center; Reference Level: Nivel 1; Vertical Justification: Middle
Dimensions - Wall Thickness: 0 m
Mechanical - Material: Cobre; Pipe Segment: Cobre - A; Schedule/Type: A; System Type: Suministro hidrónico; Connection Type: Generic; Roughness: 0.00000254 m; System Classification: Hydronic Supply; System Name: Suministro hidrónico 3
Mechanical - Flow - Additional Flow: 0 dm3/s; Flow: 0 dm3/s; Flow State: Laminar; Friction Factor: 0; Pressure Drop: 0 Pa; Reynolds Number: 0; Velocity: 0 m/s; Velocity Pressure: 0 Pa; Friction: 0
Phasing - Phase Created: Nueva construcción
Insulation - Insulation Thickness: 0 m
AboveGround - AboveGround: yes
Name (Pipe Types:Oxigeno:...) | InvertElevation (m) = Lower End Bottom Elevation (m) = Lower End Invert Elevation (m) = Invert Elevation (m) = Lower End Bottom of Insulation Elevation (m) | Pset_FlowSegmentDiameter, Diameter (m) = Inside Diameter (m) = Outside Diameter (m) = Mechanical, Diameter (m) | Qto_PipeSegmentBaseQuantities, Length (m) = Dimensions, Length (m) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) = Area (m2) | Slope | End Middle Elevation (m) | Lower End Centerline Elevation (m) | Lower End Obvert Elevation (m) = Lower End Top Elevation (m) = Lower End Top of Insulation Elevation (m) | Middle Elevation (m) = Start Middle Elevation (m) | Upper End Bottom Elevation (m) = Upper End Invert Elevation (m) = Upper End Bottom of Insulation Elevation (m) | Upper End Centerline Elevation (m) | Upper End Obvert Elevation (m) = Upper End Top Elevation (m) = Upper End Top of Insulation Elevation (m) | Size | Relative Roughness | Section | Overall Size
910104 | 3.444 | 0.012 | 1.57212 | 0.00011308 | 0.0592677 | 0 | 3.45 | 3.45 | 3.456 | 3.45 | 3.444 | 3.45 | 3.456 | 0.012ø | 0.000211667 | 191 | 12 mmø
910111 | 3.444 | 0.012 | 0.928794 | 0.00011308 | 0.0350147 | 0 | 3.45 | 3.45 | 3.456 | 3.45 | 3.444 | 3.45 | 3.456 | 0.012ø | 0.000211667 | 191 | 12 mmø
910141 | 3.4405 | 0.019 | 1.65402 | 0.000283486 | 0.0987291 | 0 | 3.45 | 3.45 | 3.4595 | 3.45 | 3.4405 | 3.45 | 3.4595 | 0.019ø | 0.000133684 | 169 | 19 mmø
910148 | 3.4405 | 0.019 | 0.712046 | 0.000283486 | 0.0425022 | 0 | 3.45 | 3.45 | 3.4595 | 3.45 | 3.4405 | 3.45 | 3.4595 | 0.019ø | 0.000133684 | 169 | 19 mmø
910164 | 3.444 | 0.012 | 2.85232 | 0.00011308 | 0.10753 | 0 | 3.45 | 3.45 | 3.456 | 3.45 | 3.444 | 3.45 | 3.456 | 0.012ø | 0.000211667 | 75 | 12 mmø
910171 | 3.444 | 0.012 | 2.57652 | 0.00011308 | 0.0971324 | 0 | 3.45 | 3.45 | 3.456 | 3.45 | 3.444 | 3.45 | 3.456 | 0.012ø | 0.000211667 | 75 | 12 mmø
910179 | 3.444 | 0.012 | 2.91827 | 0.00011308 | 0.110016 | 0 | 3.45 | 3.45 | 3.456 | 3.45 | 3.444 | 3.45 | 3.456 | 0.012ø | 0.000211667 | 75 | 12 mmø
910196 | 3.4405 | 0.019 | 3.61116 | 0.000283486 | 0.215551 | 0 | 3.45 | 3.45 | 3.4595 | 3.45 | 3.4405 | 3.45 | 3.4595 | 0.019ø | 0.000133684 | 74 | 19 mmø
910292 | 3.444 | 0.012 | 4.2898 | 0.00011308 | 0.161722 | 0 | 3.45 | 3.45 | 3.456 | 3.45 | 3.444 | 3.45 | 3.456 | 0.012ø | 0.000211667 | 17 | 12 mmø
910304 | 3.444 | 0.012 | 0.910368 | 0.00011308 | 0.0343201 | 0 | 3.45 | 3.45 | 3.456 | 3.45 | 3.444 | 3.45 | 3.456 | 0.012ø | 0.000211667 | 19 | 12 mmø
910399 | 3.444 | 0.012 | 1.90907 | 0.00011308 | 0.0719704 | 0 | 3.45 | 3.45 | 3.456 | 3.45 | 3.444 | 3.45 | 3.456 | 0.012ø | 0.000211667 | 25 | 12 mmø
910481 | 3.444 | 0.012 | 1.30578 | 0.00011308 | 0.0492266 | 0 | 3.45 | 3.45 | 3.456 | 3.45 | 3.444 | 3.45 | 3.456 | 0.012ø | 0.000211667 | 187 | 12 mmø
910494 | 3.4405 | 0.019 | 4.20886 | 0.000283486 | 0.251228 | 0 | 3.45 | 3.45 | 3.4595 | 3.45 | 3.4405 | 3.45 | 3.4595 | 0.019ø | 0.000133684 | 30 | 19 mmø
910659 | 3.4405 | 0.019 | 10.26 | 0.000283486 | 0.612422 | 0 | 3.45 | 3.45 | 3.4595 | 3.45 | 3.4405 | 3.45 | 3.4595 | 0.019ø | 0.000133684 | 111 | 19 mmø
911433 | 3.444 | 0.012 | 0.204691 | 0.00011308 | 0.00771668 | 0 | 3.45 | 3.45 | 3.456 | 3.45 | 3.444 | 3.45 | 3.456 | 0.012ø | 0.000211667 | 191 | 12 mmø
911718 | 3.444 | 0.012 | 4.93002 | 0.00011308 | 0.185857 | 0 | 3.45 | 3.45 | 3.456 | 3.45 | 3.444 | 3.45 | 3.456 | 0.012ø | 0.000211667 | 77 | 12 mmø
911858 | 3.444 | 0.012 | 0.834224 | 0.00011308 | 0.0314495 | 0 | 3.45 | 3.45 | 3.456 | 3.45 | 3.444 | 3.45 | 3.456 | 0.012ø | 0.000211667 | 79 | 12 mmø
911946 | 3.444 | 0.012 | 0.827874 | 0.00011308 | 0.0312101 | 0 | 3.45 | 3.45 | 3.456 | 3.45 | 3.444 | 3.45 | 3.456 | 0.012ø | 0.000211667 | 1 | 12 mmø
911957 | 3.444 | 0.012 | 0.827874 | 0.00011308 | 0.0312101 | 0 | 3.45 | 3.45 | 3.456 | 3.45 | 3.444 | 3.45 | 3.456 | 0.012ø | 0.000211667 | 174 | 12 mmø
912172 | 3.444 | 0.012 | 2.35518 | 0.00011308 | 0.088788 | 0 | 3.45 | 3.45 | 3.456 | 3.45 | 3.444 | 3.45 | 3.456 | 0.012ø | 0.000211667 | 138 | 12 mmø
912389 | 3.444 | 0.012 | 4.87973 | 0.00011308 | 0.183962 | 0 | 3.45 | 3.45 | 3.456 | 3.45 | 3.444 | 3.45 | 3.456 | 0.012ø | 0.000211667 | 87 | 12 mmø
912435 | 3.4405 | 0.019 | 1.91452 | 0.000283486 | 0.114278 | 0 | 3.45 | 3.45 | 3.4595 | 3.45 | 3.4405 | 3.45 | 3.4595 | 0.019ø | 0.000133684 | 73 | 19 mmø
912461 | 3.444 | 0.012 | 0.878161 | 0.00011308 | 0.0331059 | 0 | 3.45 | 3.45 | 3.456 | 3.45 | 3.444 | 3.45 | 3.456 | 0.012ø | 0.000211667 | 141 | 12 mmø
912527 | 3.444 | 0.012 | 1.64277 | 0.00011308 | 0.061931 | 0 | 3.45 | 3.45 | 3.456 | 3.45 | 3.444 | 3.45 | 3.456 | 0.012ø | 0.000211667 | 140 | 12 mmø
912539 | 3.444 | 0.012 | 0.878161 | 0.00011308 | 0.0331059 | 0 | 3.45 | 3.45 | 3.456 | 3.45 | 3.444 | 3.45 | 3.456 | 0.012ø | 0.000211667 | 140 | 12 mmø
912765 | 3.444 | 0.012 | 0.585672 | 0.00011308 | 0.0220793 | 0 | 3.45 | 3.45 | 3.456 | 3.45 | 3.444 | 3.45 | 3.456 | 0.012ø | 0.000211667 | 141 | 12 mmø
912769 | 3.4405 | 0.019 | 6.24536 | 0.000283486 | 0.372787 | 0 | 3.45 | 3.45 | 3.4595 | 3.45 | 3.4405 | 3.45 | 3.4595 | 0.019ø | 0.000133684 | 82 | 19 mmø
913003 | 3.444 | 0.012 | 4.87973 | 0.00011308 | 0.183962 | 0 | 3.45 | 3.45 | 3.456 | 3.45 | 3.444 | 3.45 | 3.456 | 0.012ø | 0.000211667 | 143 | 12 mmø
913023 | 3.444 | 0.012 | 0.878161 | 0.00011308 | 0.0331059 | 0 | 3.45 | 3.45 | 3.456 | 3.45 | 3.444 | 3.45 | 3.456 | 0.012ø | 0.000211667 | 147 | 12 mmø
913035 | 3.444 | 0.012 | 0.871811 | 0.00011308 | 0.0328665 | 0 | 3.45 | 3.45 | 3.456 | 3.45 | 3.444 | 3.45 | 3.456 | 0.012ø | 0.000211667 | 175 | 12 mmø
913126 | 3.444 | 0.012 | 0.878161 | 0.00011308 | 0.0331059 | 0 | 3.45 | 3.45 | 3.456 | 3.45 | 3.444 | 3.45 | 3.456 | 0.012ø | 0.000211667 | 145 | 12 mmø
913148 | 3.444 | 0.012 | 0.818855 | 0.00011308 | 0.0308701 | 0 | 3.45 | 3.45 | 3.456 | 3.45 | 3.444 | 3.45 | 3.456 | 0.012ø | 0.000211667 | 144 | 12 mmø
913632 | 3.444 | 0.012 | 0.871811 | 0.00011308 | 0.0328665 | 0 | 3.45 | 3.45 | 3.456 | 3.45 | 3.444 | 3.45 | 3.456 | 0.012ø | 0.000211667 | 176 | 12 mmø
913686 | 3.444 | 0.012 | 0.899995 | 0.00011308 | 0.033929 | 0 | 3.45 | 3.45 | 3.456 | 3.45 | 3.444 | 3.45 | 3.456 | 0.012ø | 0.000211667 | 146 | 12 mmø
913890 | 3.4405 | 0.019 | 2.45605 | 0.000283486 | 0.146603 | 0 | 3.45 | 3.45 | 3.4595 | 3.45 | 3.4405 | 3.45 | 3.4595 | 0.019ø | 0.000133684 | 88 | 19 mmø
914201 | 3.444 | 0.012 | 0.478599 | 0.00011308 | 0.0180428 | 0 | 3.45 | 3.45 | 3.456 | 3.45 | 3.444 | 3.45 | 3.456 | 0.012ø | 0.000211667 | 183 | 12 mmø
914287 | 3.444 | 0.012 | 0.478599 | 0.00011308 | 0.0180428 | 0 | 3.45 | 3.45 | 3.456 | 3.45 | 3.444 | 3.45 | 3.456 | 0.012ø | 0.000211667 | 182 | 12 mmø
914324 | 3.444 | 0.012 | 0.484949 | 0.00011308 | 0.0182822 | 0 | 3.45 | 3.45 | 3.456 | 3.45 | 3.444 | 3.45 | 3.456 | 0.012ø | 0.000211667 | 124 | 12 mmø
914363 | 3.444 | 0.012 | 1.54578 | 0.00011308 | 0.0582743 | 0 | 3.45 | 3.45 | 3.456 | 3.45 | 3.444 | 3.45 | 3.456 | 0.012ø | 0.000211667 | 124 | 12 mmø
914419 | 3.444 | 0.012 | 5.25912 | 0.00011308 | 0.198264 | 0 | 3.45 | 3.45 | 3.456 | 3.45 | 3.444 | 3.45 | 3.456 | 0.012ø | 0.000211667 | 180 | 12 mmø
914758 | 3.444 | 0.012 | 1.90434 | 0.00011308 | 0.071792 | 0 | 3.45 | 3.45 | 3.456 | 3.45 | 3.444 | 3.45 | 3.456 | 0.012ø | 0.000211667 | 179 | 12 mmø
916042 | 3.444 | 0.012 | 0.516039 | 0.00011308 | 0.0194542 | 0 | 3.45 | 3.45 | 3.456 | 3.45 | 3.444 | 3.45 | 3.456 | 0.012ø | 0.000211667 | 100 | 12 mmø
921011 | 3.4375 | 0.025 | 4.90488 | 0.0004908 | 0.385228 | 0 | 3.45 | 3.45 | 3.4625 | 3.45 | 3.4375 | 3.45 | 3.4625 | 0.025ø | 0.0001016 | 226 | 25 mmø
921098 | 3.4375 | 0.025 | 19.8005 | 0.0004908 | 1.55512 | 0 | 3.45 | 3.45 | 3.4625 | 3.45 | 3.4375 | 3.45 | 3.4625 | 0.025ø | 0.0001016 | 83 | 25 mmø
921111 | 3.4375 | 0.025 | 5.13485 | 0.0004908 | 0.40329 | 0 | 3.45 | 3.45 | 3.4625 | 3.45 | 3.4375 | 3.45 | 3.4625 | 0.025ø | 0.0001016 | 226 | 25 mmø
921281 | 3.4375 | 0.025 | 0.916772 | 0.0004908 | 0.0720031 | 0 | 3.45 | 3.45 | 3.4625 | 3.45 | 3.4375 | 3.45 | 3.4625 | 0.025ø | 0.0001016 | 84 | 25 mmø
922169 | -0.424017 | 0.025 | 9.77117 | 0.0004908 | 0.767426 | 0 | -0.411517 | -0.411517 | -0.399017 | -0.411517 | -0.424017 | -0.411517 | -0.399017 | 0.025ø | 0.0001016 | 226 | 25 mmø
922709 | -0.39088 | 0.025 | 2.81024 | 0.0004908 | 0.220716 |  | 2.41936 | -0.39088 | -0.39088 | -0.39088 | 2.41936 | 2.41936 | 2.41936 | 0.025ø | 0.0001016 | 226 | 25 mmø
922987 | 2.4275 | 0.025 | 2.03618 | 0.0004908 | 0.159921 | 0 | 2.44 | 2.44 | 2.4525 | 2.44 | 2.4275 | 2.44 | 2.4525 | 0.025ø | 0.0001016 | 198 | 25 mmø
923552 | 3.4405 | 0.019 | 3.34916 | 0.000283486 | 0.199912 | 0 | 3.45 | 3.45 | 3.4595 | 3.45 | 3.4405 | 3.45 | 3.4595 | 0.019ø | 0.000133684 | 166 | 19 mmø
927967 | 3.4405 | 0.019 | 3.48711 | 0.000283486 | 0.208147 | 0 | 3.45 | 3.45 | 3.4595 | 3.45 | 3.4405 | 3.45 | 3.4595 | 0.019ø | 0.000133684 | 168 | 19 mmø
928349 | 1.74901 | 0.019 | 1.68355 | 0.000283486 | 0.100492 |  | 1.74901 | 1.74901 | 1.74901 | 3.43256 | 3.43256 | 3.43256 | 3.43256 | 0.019ø | 0.000133684 | 168 | 19 mmø
928383 | 1.72207 | 0.019 | 0.236061 | 0.000283486 | 0.0140905 | 0 | 1.73157 | 1.73157 | 1.74107 | 1.73157 | 1.72207 | 1.73157 | 1.74107 | 0.019ø | 0.000133684 | 169 | 19 mmø
928395 | 1.74901 | 0.019 | 1.68355 | 0.000283486 | 0.100492 |  | 1.74901 | 1.74901 | 1.74901 | 3.43256 | 3.43256 | 3.43256 | 3.43256 | 0.019ø | 0.000133684 | 169 | 19 mmø
928412 | 3.4405 | 0.019 | 0.116202 | 0.000283486 | 0.00693612 | 0 | 3.45 | 3.45 | 3.4595 | 3.45 | 3.4405 | 3.45 | 3.4595 | 0.019ø | 0.000133684 | 169 | 19 mmø
928468 | 3.4405 | 0.019 | 0.131202 | 0.000283486 | 0.00783148 | 0 | 3.45 | 3.45 | 3.4595 | 3.45 | 3.4405 | 3.45 | 3.4595 | 0.019ø | 0.000133684 | 168 | 19 mmø
933010 | 1.72207 | 0.019 | 0.156061 | 0.000283486 | 0.00931533 | 0 | 1.73157 | 1.73157 | 1.74107 | 1.73157 | 1.72207 | 1.73157 | 1.74107 | 0.019ø | 0.000133684 | 168 | 19 mmø
933497 | 3.4405 | 0.019 | 0.08841 | 0.000283486 | 0.00527722 | 0 | 3.45 | 3.45 | 3.4595 | 3.45 | 3.4405 | 3.45 | 3.4595 | 0.019ø | 0.000133684 | 166 | 19 mmø
933616 | 1.73744 | 0.019 | 1.69512 | 0.000283486 | 0.101182 |  | 1.73744 | 1.73744 | 1.73744 | 3.43256 | 3.43256 | 3.43256 | 3.43256 | 0.019ø | 0.000133684 | 166 | 19 mmø
933625 | 1.7105 | 0.019 | 0.236857 | 0.000283486 | 0.014138 | 0 | 1.72 | 1.72 | 1.7295 | 1.72 | 1.7105 | 1.72 | 1.7295 | 0.019ø | 0.000133684 | 172 | 19 mmø
933636 | 1.73744 | 0.019 | 1.69513 | 0.000283486 | 0.101182 |  | 1.73744 | 1.73744 | 1.73744 | 3.43256 | 3.43256 | 3.43256 | 3.43256 | 0.019ø | 0.000133684 | 172 | 19 mmø
933654 | 3.4405 | 0.019 | 0.22191 | 0.000283486 | 0.0132459 | 0 | 3.45 | 3.45 | 3.4595 | 3.45 | 3.4405 | 3.45 | 3.4595 | 0.019ø | 0.000133684 | 172 | 19 mmø
933755 | 1.7105 | 0.019 | 0.172911 | 0.000283486 | 0.0103211 | 0 | 1.72 | 1.72 | 1.7295 | 1.72 | 1.7105 | 1.72 | 1.7295 | 0.019ø | 0.000133684 | 166 | 19 mmø
936108 | 1.64621 | 0.012 | 1.78985 | 0.00011308 | 0.0674759 |  | 3.43606 | 1.64621 | 1.64621 | 1.64621 | 3.43606 | 3.43606 | 3.43606 | 0.012ø | 0.000211667 | 75 | 12 mmø
936236 | 1.64621 | 0.012 | 1.78985 | 0.00011308 | 0.0674759 |  | 3.43606 | 1.64621 | 1.64621 | 1.64621 | 3.43606 | 3.43606 | 3.43606 | 0.012ø | 0.000211667 | 79 | 12 mmø
