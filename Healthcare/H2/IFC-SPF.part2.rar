Properties of the parts of a building model (IFC4), part 2 of 6

# IfcDistributionPort (1740)
Name | FlowDirection | PredefinedType | SystemType | Group
Port_933076_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_933212_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_933078_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_933212_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_933497_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_933505_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_933497_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_933531_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_933531_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_933616_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_933541_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_933555_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_933549_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_933895_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_933549_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_933584_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_933555_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_933795_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_933559_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_933582_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_933559_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_933584_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_933582_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937118_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_933616_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_933631_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_933625_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_933870_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_933625_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_933662_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_933631_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_933755_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_933636_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_933658_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_933636_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_933662_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_933654_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_933656_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_933654_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_933658_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_933656_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937078_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_933752_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_933870_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_933752_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_933872_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_933755_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_933872_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_933793_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_933895_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_933793_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_933897_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_933795_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_933897_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936045_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936108_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936045_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936138_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936108_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936531_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936138_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936512_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936233_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936236_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936233_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936242_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936236_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936554_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936242_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936573_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936264_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936267_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936264_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936273_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936267_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936598_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936273_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936619_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936292_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936295_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936292_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936301_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936295_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936650_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936301_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936671_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936318_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936321_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936318_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936327_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936321_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936700_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936327_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936719_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936344_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936347_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936344_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936353_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936347_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936761_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936353_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936742_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936370_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936373_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936370_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936379_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936373_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936803_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936379_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936784_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936398_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936401_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936398_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936407_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936401_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936828_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936407_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936849_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936424_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936427_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936424_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936433_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936427_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936895_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936433_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936874_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936452_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936455_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936452_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936461_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936455_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936918_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936461_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936937_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936552_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936595_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936594_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936595_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936646_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936647_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936667_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936668_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936782_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936846_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936801_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936825_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936824_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936825_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936845_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936846_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936870_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936871_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936871_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936935_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936891_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936892_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936892_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936916_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936956_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937071_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936956_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937111_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937013_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937244_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937071_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937087_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937077_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937245_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937077_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937078_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937077_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937085_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937111_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937127_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937117_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937118_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937117_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937125_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937149_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937238_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937149_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937199_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937199_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937215_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937205_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937206_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937205_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937213_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937238_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937254_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937244_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937245_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937244_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937252_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937273_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937276_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937273_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937282_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937276_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937502_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937282_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937525_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937305_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937308_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937305_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937314_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937308_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937456_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937314_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937479_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937331_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937334_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937331_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937340_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937334_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937412_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937340_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937433_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937452_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937499_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937498_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937499_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937521_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937522_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937543_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937546_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937543_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937552_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937544_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_953718_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937544_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_953722_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937546_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_953718_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937550_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_953699_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937550_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_953703_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937552_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_953699_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937581_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937584_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937581_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937590_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937582_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937771_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937582_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937775_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937584_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937771_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937588_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937783_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937588_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937787_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937590_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937787_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937609_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937612_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937609_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937618_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937610_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937804_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937610_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937808_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937612_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937804_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937616_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937823_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937616_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937827_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937618_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937823_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937635_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937638_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937635_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937644_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937636_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937848_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937636_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937852_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937638_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937848_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937642_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937869_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937642_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937873_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937644_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937869_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937675_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937678_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937675_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937684_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937676_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937903_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937676_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937907_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937678_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937907_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937682_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937879_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937682_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937883_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937684_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937883_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937701_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937704_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937701_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937710_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937702_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937895_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937702_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937899_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937704_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937899_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937708_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937887_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937708_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937891_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937710_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937891_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937729_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937732_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937729_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937738_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937730_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937919_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937730_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937923_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937732_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937923_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937736_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937911_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937736_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937915_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937738_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937915_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937775_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937776_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937783_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937784_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937784_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937827_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937879_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937880_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937880_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937887_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937887_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937888_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937888_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937911_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937895_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937904_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937895_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937896_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937896_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937919_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937903_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937904_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937911_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937912_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937919_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937920_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937937_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937940_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937937_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937944_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937938_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_938061_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937938_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_938065_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937940_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_938065_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937942_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_938053_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937942_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_938057_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937944_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_938057_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937986_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937989_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937986_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937993_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937987_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_938069_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937987_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_938073_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937989_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_938073_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937991_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_938045_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937991_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_938049_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937993_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_938049_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_938010_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_938013_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_938010_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_938017_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_938011_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_938041_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_938011_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_938021_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_938013_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_938021_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_938015_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_938035_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_938015_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_938037_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_938017_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_938037_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_938035_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_938046_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_938041_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_938070_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_938045_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_938054_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_938045_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_938046_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_938053_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_938054_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_938061_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_938062_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_938062_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_938069_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_938069_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_938070_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_938105_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_938108_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_938105_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_938112_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_938106_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_938286_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_938106_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_938288_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_938108_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_938288_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_938110_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_938300_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_938110_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_938302_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_938112_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_938302_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_938278_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_938279_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_938278_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_938286_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_938292_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_938293_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_938292_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_938300_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
InPort_940508_1 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940090_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940510_1 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940091_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940536_1 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940115_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940538_1 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940116_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
OutPort_940126_1 | SOURCE | PIPE
OutPort_940127_1 | SOURCE | PIPE
OutPort_940128_1 | SOURCE | PIPE
OutPort_940129_1 | SOURCE | PIPE
OutPort_940130_1 | SOURCE | PIPE
OutPort_940131_1 | SOURCE | PIPE
OutPort_940132_1 | SOURCE | PIPE
OutPort_940133_1 | SOURCE | PIPE
OutPort_940134_1 | SOURCE | PIPE
OutPort_940135_1 | SOURCE | PIPE
OutPort_940136_1 | SOURCE | PIPE
OutPort_940137_1 | SOURCE | PIPE
OutPort_940138_1 | SOURCE | PIPE
OutPort_940139_1 | SOURCE | PIPE
OutPort_940147_1 | SOURCE | PIPE
OutPort_940148_1 | SOURCE | PIPE
OutPort_940149_1 | SOURCE | PIPE
OutPort_940150_1 | SOURCE | PIPE
OutPort_940151_1 | SOURCE | PIPE
OutPort_940152_1 | SOURCE | PIPE
OutPort_940153_1 | SOURCE | PIPE
OutPort_940154_1 | SOURCE | PIPE
OutPort_940155_1 | SOURCE | PIPE
OutPort_940156_1 | SOURCE | PIPE
OutPort_940157_1 | SOURCE | PIPE
OutPort_940158_1 | SOURCE | PIPE
OutPort_940159_1 | SOURCE | PIPE
OutPort_940160_1 | SOURCE | PIPE
OutPort_940176_1 | SOURCE | PIPE
OutPort_940177_1 | SOURCE | PIPE
OutPort_940178_1 | SOURCE | PIPE
OutPort_940179_1 | SOURCE | PIPE
InPort_940202_0 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940508_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940216_1 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940202_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940210_0 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940510_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940212_1 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940210_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940588_0 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940212_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940578_1 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940216_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940245_0 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940536_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940259_1 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940245_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940253_0 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940538_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940255_1 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940253_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940641_0 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940255_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940633_1 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940259_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940512_1 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940271_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940514_1 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940272_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940540_1 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940273_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940542_1 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940274_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940621_3 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940275_0 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940275_1 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940283_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940277_0 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940512_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940283_1 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940277_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940279_0 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940514_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940281_1 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940279_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940619_0 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940281_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940672_3 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940285_0 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940285_1 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940293_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940287_0 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940540_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940293_1 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940287_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940289_0 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940542_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940291_1 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940289_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940670_0 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940291_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940516_1 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940308_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940518_1 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940309_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940544_1 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940310_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940546_1 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940311_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940615_3 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940312_0 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940312_1 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940320_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940314_0 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940516_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940320_1 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940314_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940316_0 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940518_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940318_1 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940316_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940613_0 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940318_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940666_3 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940322_0 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940322_1 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940330_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940324_0 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940544_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940330_1 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940324_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940326_0 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940546_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940328_1 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940326_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940664_0 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940328_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940520_1 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940352_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940522_1 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940353_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940548_1 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940354_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940550_1 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940355_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940609_3 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940356_0 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940356_1 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940364_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940358_0 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940520_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940364_1 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940358_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940360_0 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940522_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940362_1 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940360_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940607_0 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940362_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940660_3 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940366_0 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940366_1 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940374_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940368_0 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940548_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940374_1 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940368_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940370_0 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940550_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940372_1 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940370_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940658_0 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940372_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940524_1 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940389_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940526_1 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940390_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940552_1 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940391_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940554_1 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940392_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940603_3 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940393_0 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940393_1 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940401_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940395_0 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940524_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940401_1 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940395_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940397_0 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940526_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940399_1 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940397_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940601_0 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940399_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940654_3 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940403_0 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940403_1 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940411_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940405_0 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940552_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940411_1 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940405_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940407_0 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940554_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940409_1 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940407_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940652_0 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940409_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940528_1 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940426_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940530_1 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940427_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940556_1 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940428_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940558_1 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940429_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940597_3 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940430_0 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940430_1 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940438_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940432_0 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940528_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940438_1 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940432_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940434_0 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940530_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940436_1 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940434_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940595_0 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940436_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940648_3 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940440_0 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940440_1 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940448_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940442_0 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940556_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940448_1 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940442_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940444_0 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940558_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940446_1 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940444_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940646_0 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940446_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940532_1 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940463_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940534_1 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940464_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940560_1 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940465_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940562_1 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940466_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940581_1 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940467_0 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940467_1 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940475_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940469_0 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940532_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940475_1 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940469_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940471_0 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940534_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940473_1 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940471_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940582_0 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940473_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940636_1 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940477_0 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940477_1 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940485_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940479_0 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940560_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940485_1 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940479_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940481_0 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940562_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940483_1 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940481_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940637_0 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940483_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940621_1 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940565_0 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940565_1 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940587_3 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940587_1 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940578_0 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940581_2 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940582_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940593_0 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940581_3 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940587_2 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940588_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940597_2 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940593_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940597_4 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940595_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940599_0 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940597_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940603_2 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940599_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940603_4 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940601_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_953428_0 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940603_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_953431_2 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940605_0 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940605_1 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940609_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940609_4 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940607_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940609_1 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940611_0 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940611_1 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940615_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940615_4 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940613_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940615_1 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940617_0 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940617_1 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940621_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940621_4 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_940619_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_940672_1 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940624_0 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940624_1 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940640_3 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940640_1 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940633_0 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940636_2 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940637_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940644_0 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940636_3 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940640_2 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940641_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940648_2 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940644_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940648_4 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940646_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940650_0 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940648_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940654_2 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940650_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940654_4 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940652_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_953465_0 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940654_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_953468_2 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940656_0 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940656_1 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940660_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940660_4 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940658_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940660_1 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940662_0 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940662_1 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940666_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940666_4 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940664_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940666_1 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940668_0 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940668_1 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940672_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_940672_4 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_940670_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
Port_943051_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_945384_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_945553_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_945384_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_945568_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
InPort_945693_1 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_945386_0 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_945386_1 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_945639_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
Port_945391_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_945407_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_945391_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_945417_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_945409_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_945417_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_945409_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_945436_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_945433_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_945436_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_945433_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_945560_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_945568_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_945560_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_945612_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_945572_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_945610_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_945572_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_945612_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_945635_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_945694_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_945693_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_945694_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_945693_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_945704_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_945704_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_945718_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_945712_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_945718_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_945712_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_945730_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_945720_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_945730_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_945720_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_945758_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_945755_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_945758_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_945755_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
InPort_953152_1 | SINK | PIPE | DOMESTICCOLDWATER | Agua fría doméstica 1
OutPort_947545_5 | SOURCE | PIPE | DOMESTICCOLDWATER | Agua fría doméstica 1
OutPort_947545_9 | SOURCE | PIPE | DOMESTICHOTWATER
InPort_947545_10 | SINK | PIPE | DOMESTICHOTWATER
InPort_947545_12 | SINK | PIPE | HEATING
InPort_953136_0 | SINK | PIPE | DOMESTICCOLDWATER | Agua fría doméstica 1
OutPort_953152_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Agua fría doméstica 1
OutPort_953136_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Agua fría doméstica 1
Port_953222_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_953228_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_953222_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_953327_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_953224_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_953288_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_953224_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
