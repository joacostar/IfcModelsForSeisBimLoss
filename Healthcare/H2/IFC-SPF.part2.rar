Properties of the parts of a building model (IFC4), part 1 of 6

# File
Description: ViewDefinition [ReferenceView_V1.2], RevitIdentifiers [ContentGUID: dfbad060-0db1-4a7d-bf27-5d40589a6bfd, VersionGUID: e55c3f18-73b8-4c70-9314-23272ae75f66, NumberOfSaves: 3], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Interno]
File name: C:\Users\Joaquin\Dropbox\BuildingProjects\2024 - Construcción Cesfam Coyhaique Con Sar Adosado\2_Modelos\all_models_2025-1-24_23.4.48\CCY_COOR-CCY_GCL_Enriched.ifc
Time: 2025-10-28T09:50:33-03:00
Written by: IfcOpenShell 0.8.3-post1
Made in: Bonsai 0.8.3-post1

# IfcProject, 2016_03
LongName: CESFAM Coyhaique; Phase: 2

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Servicio de Salud de Aysén; Project Address: Calle 2, s/n. Lote 1C.; Project Issue Date: Marzo 2017; Project Name: CESFAM Coyhaique; Project Number: 2016_03; Project Status: 2
Identity Data - Author: Astudillo y Aparicio Asociados Ltda.; Organization Description: Arquitectura e ingeniería integrada; Organization Name: Astudillo y Aparicio Asociados Ltda.

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 2
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingSystemCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Servicio de Salud de Aysén; Project Address: Calle 2, s/n. Lote 1C.; Project Issue Date: Marzo 2017; Project Name: CESFAM Coyhaique; Project Number: 2016_03; Project Status: 2
Identity Data - Author: Astudillo y Aparicio Asociados Ltda.; Organization Description: Arquitectura e ingeniería integrada; Organization Name: Astudillo y Aparicio Asociados Ltda.

# IfcBuildingStorey: Level:Extremo inicial 8 mm (2)
Other - Category: Levels; Family: Level; Family and Type: Level: Extremo inicial 8 mm; Type: Extremo inicial 8 mm; Type Id: 305
Dimensions - Computation Height: 0 m
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Survey Point
Graphics(Type) - Color: 0; Line Pattern: Centro; Line Weight: 1; Symbol: M_Extremo inicial de nivel - Círculo; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Extremo inicial 8 mm
Name | LongName = Name | Elevation (m) | Constraints, Elevation (m)
Nivel 1 | Nivel 1 | 0 | 317.15
Nivel 2 | Nivel 2 | 4.25 | 321.4

# IfcCompressor: Compressor-Dental_Operatory-Air_Techniques-AirStar:2 Simultaneous Users, Compressor-Dental_Operatory-Air_Techniques-AirStar:2 Simultaneous Users:943051
In: Nivel 1
Type - PredefinedType: TWINSCREW; Material: Powder Coat - Air Techniques - Black, Powder Coat - Air Techniques - Blue, Steel - Air Techniques
Type - Other - Category: Mechanical Equipment; Family Name: Compressor-Dental_Operatory-Air_Techniques-AirStar
Type - Constraints - Default Elevation: 13.1234 m
Type - Data - bim-seek-BOPCEditionNumber: 1; bim-seek-source_url: http://seek.autodesk.com/product/latest/agg/airtechniquesinc/Air-Techniques-Inc/AirStar70; mspec-BOPCEditionNumber: 1
Type - Electrical - Apparent Load: 0 W; Full Load Amps: 8 A; Horsepower: 559.275 W; Load Classification: Other; Number of Poles: 1; Power Factor: 1; Voltage: 115 V
Type - General - Date of publishing: 4/1/2014; Design country: United States; Edition number: 1; Manufacturer country: United States; Manufacturer name: Air techniques, Inc.; Nominal height: 35; Nominal width: 47.75; Product family: Dental Equipment; Product group: Air Compressor; Product SKU: AirStar-70-Air-Compressor; QR code: http://bimobject.com/airtechniques/product/AirStar-70-Air-Compressor; Region North America: AG, AI, AW, BB, BL, BM, BQ, BS, BZ, CA, CR, CU, CW, DM, DO, GD, GL, GP, GT, HN, HT, JM, KN, KY, LC, MF, MQ, MS, MX, NI, PA, PM, PR, SV, SX, TC, TT, US, VC, VG, VI; Weight Net (Kg): 430
Type - Identity Data - Copyright: Copyright © 2014 Air Techniques, Inc.; Date Last Modified: July 10, 2014; Description: Compressor With Membrane Dryer, Maximum 2 Simultaneous Users; Equipment Abbreviation: AS; Family Version: 1.0; Manufacturer: Air Techniques, Inc.; Model: AS10; Model Disclaimer: Contact Air Techniques, Inc. for More Information; OmniClass Number: 23.40.70.11.14.14; OmniClass Title: Dental Equipment; Original Creation Date: July 10, 2014; Product data url: https://bimobject.com/airtechniques/product/AirStar-70-Air-Compressor; Product Documentation Link: http://www.airtechniques.com/userfiles/files/AirStar%20Brochure_2013_PN9922-316%20RevF.pdf; Product Page URL: http://www.airtechniques.com/products/airstar-10.html; Type Name: 2 Simultaneous Users; URL: http://www.airtechniques.com/
Type - Materials and Finishes - Material main: Metal; Product Material: Powder Coat - Air Techniques - Blue
Type - Mechanical - Pump Air Flow: 1.17987 dm3/s; Tank Size: 0.0227125 m3
Type - Structural - Weight: 0.711715 kN
Type - Pset_ManufacturerTypeInformation - Manufacturer: Air Techniques, Inc.
Classification: D20 (FEMAP58)
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: Compressor-Dental_Operatory-Air_Techniques-AirStar:2 Simultaneous Users
Pset_EnvironmentalImpactIndicators - Reference: Compressor-Dental_Operatory-Air_Techniques-AirStar:2 Simultaneous Users
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 2.90738 m2; NetVolume: 0.125578 m3
Other - Family: Compressor-Dental_Operatory-Air_Techniques-AirStar; Family and Type: Compressor-Dental_Operatory-Air_Techniques-AirStar: 2 Simultaneous Users; Type: 2 Simultaneous Users; Type Id: 943015
Constraints - Level: Nivel 1; Elevation from Level: -0.45 m; Offset from Host: -0.4 m; Schedule Level: Nivel 1; Work Plane: Linked Revit Model : CCY_EST.rvt
Dimensions - Area: 2.54618 m2; Depth: 0.568198 m; Height: 0.759866 m; Volume: 0.114051 m3; Width: 0.635381 m
Graphics - Has Sound Cover: yes
Identity Data - Part Description: Compressor With Membrane Dryer, Maximum 2 Simultaneous Users; Part Number: AS10
Mechanical - System Classification: Power
Phasing - Phase Created: Nueva construcción
AboveGround - AboveGround: yes

# IfcCompressor: D4001 - Compressor, Dental Air, System:D4001 - Compressor, Dental Air, System 53"x 25", D4001 - Compressor, Dental Air, System:D4001 - Compressor, Dental Air, System 53"x 25":947578
In: Nivel 1
Type - PredefinedType: RECIPROCATING; Material: Paint - Red, Metal - Aluminium, Rubber - Black, Metal - Aluminum, Brushed
Type - Other - Category: Mechanical Equipment; Family Name: D4001 - Compressor, Dental Air, System
Type - Analysis Results - Capacity: 0.3855 m3
Type - Constraints - Default Elevation: 0 m
Type - Dimensions - Length: 1.5 m; Tank End Cap Radius: 0.326 m
Type - Identity Data - Type Name: D4001 - Compressor, Dental Air, System 53"x 25"
Type - Materials and Finishes - Belt: Rubber - Black; Motor: Metal - Aluminium; Pullys: Metal - Aluminum, Brushed; Tank: Paint - Red
Classification: D20 (FEMAP58)
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: D4001 - Compressor, Dental Air, System:D4001 - Compressor, Dental Air, System 53"x 25"
Pset_EnvironmentalImpactIndicators - Reference: D4001 - Compressor, Dental Air, System:D4001 - Compressor, Dental Air, System 53"x 25"
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 5.97971 m2; NetVolume: 0.410117 m3
Other - Family: D4001 - Compressor, Dental Air, System; Family and Type: D4001 - Compressor, Dental Air, System: D4001 - Compressor, Dental Air, System 53"x 25"; IfcType: D4001 - Compressor, Dental Air, System; Type: D4001 - Compressor, Dental Air, System 53"x 25"; Type Id: 947627
Constraints - Level: Nivel 1; Moves With Nearby Elements: no; Elevation from Level: -0.4 m; Host: Level : Nivel 1; Offset from Host: -0.4 m
Dimensions - Area: 2.98761 m2; Volume: 0.410113 m3
Identity Data - Mark: D4001
Phasing - Phase Created: Nueva construcción
AboveGround - AboveGround: yes

# IfcDistributionChamberElement: Caja de Valvulas:Caja de Valvulas (2)
In: Nivel 1
Type - PredefinedType: VALVECHAMBER; Material: <Unnamed>
Type - Other - Category: Mechanical Equipment; Family Name: Caja de Valvulas
Type - Constraints - Default Elevation: 0 m
Type - Identity Data - Type Name: Caja de Valvulas
Classification: D (FEMAP58)
Pset_BuildingElementProxyCommon - Reference: Caja de Valvulas:Caja de Valvulas; IsExternal: no
Pset_EnvironmentalImpactIndicators - Reference: Caja de Valvulas:Caja de Valvulas
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.5326 m2; NetVolume: 0.001892 m3
Other - Family: Caja de Valvulas; Family and Type: Caja de Valvulas: Caja de Valvulas; Type: Caja de Valvulas; Type Id: 926453
Constraints - Level: Nivel 1; Elevation from Level: 1.53 m; Host: Level : Nivel 1; Moves With Nearby Elements: no; Offset from Host: 1.53 m
Dimensions - Area: 0.2663 m2; Volume: 0.001892 m3
Phasing - Phase Created: Nueva construcción
AboveGround - AboveGround: yes
Name (Caja de Valvulas:Caja de Valvulas:...) | Mark
927263 | 1
927514 | 2

# IfcDistributionPort (1740)
Description: Flow
Name | FlowDirection | PredefinedType | SystemType | Group
Port_909914_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936510_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_909914_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936512_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_909923_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936510_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_909923_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_909945_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_909939_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_909945_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_909939_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_909961_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_909961_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_909963_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_909963_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_916331_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_910021_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_938053_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_910021_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_910036_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_910028_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_910036_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_910028_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_910044_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_910038_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_910044_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_910038_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_910054_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_910054_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_910056_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_910056_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_917430_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_910058_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_910556_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_910058_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_917558_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_910066_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_927879_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_910066_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_917562_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_910104_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_910134_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_910104_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_938043_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_910111_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_917485_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_910111_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_910134_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_910141_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_917556_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_910141_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_910280_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_910148_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_928414_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_910148_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_917556_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_910164_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936529_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_910164_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936531_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_910171_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_910223_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_910171_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936529_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_910179_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_910246_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_910179_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_910223_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_910196_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_911786_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_910196_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_910244_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_910244_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_910246_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_910280_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_910520_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_910280_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_910494_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_910292_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_910520_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_910292_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_910530_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_910304_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_910526_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_910304_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_953722_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_910336_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_910526_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_910336_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_910528_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_910336_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_910530_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_910399_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937775_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_910399_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937808_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_910481_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937903_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_910481_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937852_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_910493_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_910659_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_910493_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_938279_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_910493_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_910518_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_910494_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_938278_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_910518_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937920_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_910528_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937776_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_910556_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_924731_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_910556_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_938293_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_910567_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_924727_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_910567_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_924731_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_910651_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937879_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_910651_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937873_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_910659_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_917483_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_911433_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_938061_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_911433_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_938043_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_911540_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 18
Port_911540_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 18
Port_911545_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_938292_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_911545_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_917429_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_911718_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_911794_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_911718_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_911856_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_911724_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_916328_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_911724_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_916338_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_911773_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_916494_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_911773_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_913922_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_911786_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_912435_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_911786_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_911794_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_911824_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936571_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_911824_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936573_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_911856_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936647_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_911858_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936552_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_911858_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936554_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_911946_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936594_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_911946_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936598_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_911957_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936646_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_911957_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936650_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_912064_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936667_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_912064_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936615_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_912072_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936615_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_912072_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936571_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_912172_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936646_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_912172_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936594_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_912211_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936667_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_912211_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936671_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_912269_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936615_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_912269_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936619_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_912389_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_912764_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_912389_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_912776_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_912391_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_916459_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_912391_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_916471_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_912435_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_912768_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_912461_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936759_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_912461_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936761_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_912488_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936717_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_912488_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936719_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_912527_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_912764_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_912527_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936698_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_912539_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936698_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_912539_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936700_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_912573_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_916459_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_912573_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936717_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_912592_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936740_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_912592_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936742_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_912764_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_912765_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_912765_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936759_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_912768_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_912769_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_912768_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_912776_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_912769_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_913097_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_913003_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_913105_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_913003_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_913107_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_913005_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_916490_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_913005_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_916502_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_913023_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936916_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_913023_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936918_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_913029_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936845_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_913029_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936849_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_913035_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936824_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_913035_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936828_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_913045_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936935_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_913045_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936937_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_913097_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_913890_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_913097_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_913105_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_913107_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_913148_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_913107_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_913686_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_913120_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936845_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_913120_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_916490_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_913122_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936782_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_913122_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936784_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_913126_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936801_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_913126_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936803_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_913148_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936824_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_913630_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936870_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_913630_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936874_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_913632_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936891_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_913632_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936895_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_913686_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_936891_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_913690_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936870_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_913690_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_916490_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_913890_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_916752_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_913922_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937206_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_913922_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_913930_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_913930_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937522_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_913989_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937521_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_913989_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937525_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_914201_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937498_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_914201_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937502_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_914287_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937452_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_914287_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937456_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_914316_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937431_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_914316_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937433_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_914324_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937410_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_914324_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937412_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_914363_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937452_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_914363_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937410_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_914417_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937213_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_914417_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937215_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_914419_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937252_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_914419_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937254_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_914473_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937205_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_914473_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937117_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_914673_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937125_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_914673_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937127_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_914758_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937085_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_914758_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937087_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_915098_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_954064_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_915098_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_923906_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_915115_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_923955_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_915115_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_923965_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_915123_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_923955_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_915123_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_924636_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_915133_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_924632_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_915133_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_924636_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_915175_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_923910_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_915175_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_921159_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_915522_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_922113_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_915522_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_915528_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_915526_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_924030_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_915526_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_924022_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_915528_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_915534_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_915534_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_915536_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_915536_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_924031_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_916031_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937521_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_916031_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937475_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_916042_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937498_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_916042_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_916760_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_916328_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936668_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_916330_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_916464_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_916330_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_916331_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_916330_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_916338_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_916459_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_916460_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_916460_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_936740_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_916463_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_916495_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_916463_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_916464_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_916463_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_916471_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_916494_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_916495_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_916494_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_916502_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_916752_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_937013_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_916752_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_916760_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_916777_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937475_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_916777_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937479_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_916786_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937475_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_916786_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937431_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_917107_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_917109_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_917107_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_921281_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_917109_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_927967_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_917203_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_924727_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_917203_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_953703_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_917429_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_917430_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_917429_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_917437_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_917437_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937912_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_917483_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_917485_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_917558_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_931635_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_917560_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_917562_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_917560_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_921331_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_917581_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_954262_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_917581_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_954264_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_917610_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_924024_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_917610_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_924026_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_919053_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920399_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_919053_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920355_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920399_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920355_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920402_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920357_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_924026_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920357_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920402_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920430_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920490_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920430_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920456_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920490_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920456_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920492_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920458_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_954264_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920458_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920492_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920514_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920586_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920514_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920529_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920521_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_925081_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920521_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920547_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920529_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920531_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920531_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_925083_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920533_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_955111_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920533_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_925079_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920541_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920547_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920541_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920571_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920568_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920656_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920568_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920571_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920652_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920583_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920788_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920583_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920586_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920784_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920644_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920656_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920644_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920654_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920652_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920654_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920778_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920788_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920778_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920786_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920784_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920786_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920835_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920962_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920835_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920953_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920962_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920953_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920960_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920958_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_924632_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920958_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_920960_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_921011_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_921278_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_921011_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_957270_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_921098_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_921280_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_921098_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_923522_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_921111_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_921278_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_921111_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_921280_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_921159_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_955102_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_921280_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_921281_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_921300_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_921328_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_921300_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_921330_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_921325_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_921330_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_921325_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_923432_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_921328_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_921577_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_921330_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_921331_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_921577_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_957192_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_921976_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_922111_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_921976_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_957311_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_921983_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_922111_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_921983_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_922121_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_922113_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_922114_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_922113_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_922121_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_922114_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_955101_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_922148_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_922752_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_922148_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_957350_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_922169_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_957366_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_922169_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_957370_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_922176_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_922686_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_922176_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_957378_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_922678_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_922686_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_922678_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_945635_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_922709_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_957370_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_922709_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_923098_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_922742_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_922752_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_922742_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_923067_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_922756_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_923067_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_922756_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_945553_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_922970_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_945610_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_922970_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_945407_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
InPort_923102_2 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_922987_0 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_922987_1 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_953478_2 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
InPort_945639_2 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_923004_0 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
InPort_923004_1 | SINK | PIPE | HEATING | Suministro hidrónico 1
OutPort_953442_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 1
Port_923098_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_953291_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
InPort_953254_1 | SINK | PIPE | HEATING | Suministro hidrónico 3
OutPort_923102_1 | SOURCE | PIPE | HEATING | Suministro hidrónico 3
Port_923432_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_923434_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_923434_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_927653_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_923522_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_923524_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_923524_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_923552_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_923552_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_933505_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_923906_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_923908_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_923908_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_923958_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_923910_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_923946_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_923946_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_923957_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_923957_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_923958_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_923957_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_923965_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_924022_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_924024_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_924030_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_924031_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_924030_3 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_924038_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_924038_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_954229_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_924727_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_924728_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_924728_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_937783_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_925079_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_925081_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_925079_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_925083_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 4
Port_927653_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_927723_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_927723_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_933541_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_927871_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_927879_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_927871_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_927887_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_927881_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_933210_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_927881_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_927914_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_927887_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_933078_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_927891_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_927912_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_927891_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_927914_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_927912_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_931635_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_927967_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_928470_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_928349_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_928472_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_928349_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_928474_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_928383_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_933266_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_928383_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_928420_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_928395_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_928416_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_928395_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_928420_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_928412_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_928414_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_928412_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_928416_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_928468_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_928470_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_928468_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_928472_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_928474_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_933010_0 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_933007_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_933266_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_933007_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_933268_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_933010_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_933268_2 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 3
Port_933076_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
Port_933210_1 | SOURCEANDSINK | PIPE | HEATING | Suministro hidrónico 1
