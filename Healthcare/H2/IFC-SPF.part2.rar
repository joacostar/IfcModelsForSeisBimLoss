Properties of the parts of a building model (IFC4), part 6 of 6

# IfcPipeSegment: Pipe Types:Oxigeno (132)
Name (Pipe Types:Oxigeno:...) | InvertElevation (m) = Lower End Bottom Elevation (m) = Lower End Invert Elevation (m) = Invert Elevation (m) = Lower End Bottom of Insulation Elevation (m) | Pset_FlowSegmentDiameter, Diameter (m) = Inside Diameter (m) = Outside Diameter (m) = Mechanical, Diameter (m) | Qto_PipeSegmentBaseQuantities, Length (m) = Dimensions, Length (m) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) = Area (m2) | Slope | End Middle Elevation (m) | Lower End Centerline Elevation (m) | Lower End Obvert Elevation (m) = Lower End Top Elevation (m) = Lower End Top of Insulation Elevation (m) | Middle Elevation (m) = Start Middle Elevation (m) | Upper End Bottom Elevation (m) = Upper End Invert Elevation (m) = Upper End Bottom of Insulation Elevation (m) | Upper End Centerline Elevation (m) | Upper End Obvert Elevation (m) = Upper End Top Elevation (m) = Upper End Top of Insulation Elevation (m) | Size | Relative Roughness | Section | Overall Size
936267 | 1.64621 | 0.012 | 1.78985 | 0.00011308 | 0.0674759 |  | 3.43606 | 1.64621 | 1.64621 | 1.64621 | 3.43606 | 3.43606 | 3.43606 | 0.012ø | 0.000211667 | 1 | 12 mmø
936295 | 1.64621 | 0.012 | 1.78985 | 0.00011308 | 0.0674759 |  | 3.43606 | 1.64621 | 1.64621 | 1.64621 | 3.43606 | 3.43606 | 3.43606 | 0.012ø | 0.000211667 | 174 | 12 mmø
936321 | 1.64621 | 0.012 | 1.78985 | 0.00011308 | 0.0674759 |  | 3.43606 | 1.64621 | 1.64621 | 1.64621 | 3.43606 | 3.43606 | 3.43606 | 0.012ø | 0.000211667 | 140 | 12 mmø
936347 | 1.64621 | 0.012 | 1.78985 | 0.00011308 | 0.0674759 |  | 3.43606 | 1.64621 | 1.64621 | 1.64621 | 3.43606 | 3.43606 | 3.43606 | 0.012ø | 0.000211667 | 141 | 12 mmø
936373 | 1.64621 | 0.012 | 1.78985 | 0.00011308 | 0.0674759 |  | 3.43606 | 1.64621 | 1.64621 | 1.64621 | 3.43606 | 3.43606 | 3.43606 | 0.012ø | 0.000211667 | 145 | 12 mmø
936401 | 1.64621 | 0.012 | 1.78985 | 0.00011308 | 0.0674759 |  | 3.43606 | 1.64621 | 1.64621 | 1.64621 | 3.43606 | 3.43606 | 3.43606 | 0.012ø | 0.000211667 | 175 | 12 mmø
936427 | 1.64621 | 0.012 | 1.78985 | 0.00011308 | 0.0674759 |  | 3.43606 | 1.64621 | 1.64621 | 1.64621 | 3.43606 | 3.43606 | 3.43606 | 0.012ø | 0.000211667 | 176 | 12 mmø
936455 | 1.64621 | 0.012 | 1.78985 | 0.00011308 | 0.0674759 |  | 3.43606 | 1.64621 | 1.64621 | 1.64621 | 3.43606 | 3.43606 | 3.43606 | 0.012ø | 0.000211667 | 147 | 12 mmø
936595 | 3.444 | 0.012 | 0.537158 | 0.00011308 | 0.0202504 | 0 | 3.45 | 3.45 | 3.456 | 3.45 | 3.444 | 3.45 | 3.456 | 0.012ø | 0.000211667 | 79 | 12 mmø
936647 | 3.444 | 0.012 | 0.323935 | 0.00011308 | 0.0122121 | 0 | 3.45 | 3.45 | 3.456 | 3.45 | 3.444 | 3.45 | 3.456 | 0.012ø | 0.000211667 | 77 | 12 mmø
936825 | 3.444 | 0.012 | 1.26578 | 0.00011308 | 0.0477186 | 0 | 3.45 | 3.45 | 3.456 | 3.45 | 3.444 | 3.45 | 3.456 | 0.012ø | 0.000211667 | 145 | 12 mmø
936892 | 3.444 | 0.012 | 0.507466 | 0.00011308 | 0.019131 | 0 | 3.45 | 3.45 | 3.456 | 3.45 | 3.444 | 3.45 | 3.456 | 0.012ø | 0.000211667 | 147 | 12 mmø
937013 | 3.4405 | 0.019 | 3.3961 | 0.000283486 | 0.202714 | 0 | 3.45 | 3.45 | 3.4595 | 3.45 | 3.4405 | 3.45 | 3.4595 | 0.019ø | 0.000133684 | 137 | 19 mmø
937071 | 1.64621 | 0.012 | 1.78985 | 0.00011308 | 0.0674759 |  | 3.43606 | 1.64621 | 1.64621 | 1.64621 | 3.43606 | 3.43606 | 3.43606 | 0.012ø | 0.000211667 | 179 | 12 mmø
937078 | 3.4405 | 0.019 | 1.08329 | 0.000283486 | 0.0646622 | 0 | 3.45 | 3.45 | 3.4595 | 3.45 | 3.4405 | 3.45 | 3.4595 | 0.019ø | 0.000133684 | 172 | 19 mmø
937238 | 1.64621 | 0.012 | 1.78985 | 0.00011308 | 0.0674759 |  | 3.43606 | 1.64621 | 1.64621 | 1.64621 | 3.43606 | 3.43606 | 3.43606 | 0.012ø | 0.000211667 | 180 | 12 mmø
937245 | 3.4405 | 0.019 | 2.07208 | 0.000283486 | 0.123683 | 0 | 3.45 | 3.45 | 3.4595 | 3.45 | 3.4405 | 3.45 | 3.4595 | 0.019ø | 0.000133684 | 136 | 19 mmø
937276 | 1.64621 | 0.012 | 1.78985 | 0.00011308 | 0.0674759 |  | 3.43606 | 1.64621 | 1.64621 | 1.64621 | 3.43606 | 3.43606 | 3.43606 | 0.012ø | 0.000211667 | 183 | 12 mmø
937308 | 1.64621 | 0.012 | 1.78985 | 0.00011308 | 0.0674759 |  | 3.43606 | 1.64621 | 1.64621 | 1.64621 | 3.43606 | 3.43606 | 3.43606 | 0.012ø | 0.000211667 | 182 | 12 mmø
937334 | 1.64621 | 0.012 | 1.78985 | 0.00011308 | 0.0674759 |  | 3.43606 | 1.64621 | 1.64621 | 1.64621 | 3.43606 | 3.43606 | 3.43606 | 0.012ø | 0.000211667 | 124 | 12 mmø
937499 | 3.444 | 0.012 | 1.75942 | 0.00011308 | 0.0663288 | 0 | 3.45 | 3.45 | 3.456 | 3.45 | 3.444 | 3.45 | 3.456 | 0.012ø | 0.000211667 | 122 | 12 mmø
937544 | 3.444 | 0.012 | 0.924777 | 0.00011308 | 0.0348633 | 0 | 3.45 | 3.45 | 3.456 | 3.45 | 3.444 | 3.45 | 3.456 | 0.012ø | 0.000211667 | 19 | 12 mmø
937546 | 1.64621 | 0.012 | 1.78985 | 0.00011308 | 0.0674759 |  | 3.43606 | 1.64621 | 1.64621 | 1.64621 | 3.43606 | 3.43606 | 3.43606 | 0.012ø | 0.000211667 | 19 | 12 mmø
937582 | 3.444 | 0.012 | 0.918427 | 0.00011308 | 0.0346239 | 0 | 3.45 | 3.45 | 3.456 | 3.45 | 3.444 | 3.45 | 3.456 | 0.012ø | 0.000211667 | 184 | 12 mmø
937584 | 1.64621 | 0.012 | 1.78985 | 0.00011308 | 0.0674759 |  | 3.43606 | 1.64621 | 1.64621 | 1.64621 | 3.43606 | 3.43606 | 3.43606 | 0.012ø | 0.000211667 | 184 | 12 mmø
937610 | 3.444 | 0.012 | 0.924777 | 0.00011308 | 0.0348633 | 0 | 3.45 | 3.45 | 3.456 | 3.45 | 3.444 | 3.45 | 3.456 | 0.012ø | 0.000211667 | 25 | 12 mmø
937612 | 1.64621 | 0.012 | 1.78985 | 0.00011308 | 0.0674759 |  | 3.43606 | 1.64621 | 1.64621 | 1.64621 | 3.43606 | 3.43606 | 3.43606 | 0.012ø | 0.000211667 | 25 | 12 mmø
937636 | 3.444 | 0.012 | 0.497893 | 0.00011308 | 0.0187701 | 0 | 3.45 | 3.45 | 3.456 | 3.45 | 3.444 | 3.45 | 3.456 | 0.012ø | 0.000211667 | 187 | 12 mmø
937638 | 1.64621 | 0.012 | 1.78985 | 0.00011308 | 0.0674759 |  | 3.43606 | 1.64621 | 1.64621 | 1.64621 | 3.43606 | 3.43606 | 3.43606 | 0.012ø | 0.000211667 | 187 | 12 mmø
937676 | 3.444 | 0.012 | 0.491543 | 0.00011308 | 0.0185307 | 0 | 3.45 | 3.45 | 3.456 | 3.45 | 3.444 | 3.45 | 3.456 | 0.012ø | 0.000211667 | 188 | 12 mmø
937678 | 1.64621 | 0.012 | 1.78985 | 0.00011308 | 0.0674759 |  | 3.43606 | 1.64621 | 1.64621 | 1.64621 | 3.43606 | 3.43606 | 3.43606 | 0.012ø | 0.000211667 | 188 | 12 mmø
937702 | 3.444 | 0.012 | 0.491543 | 0.00011308 | 0.0185307 | 0 | 3.45 | 3.45 | 3.456 | 3.45 | 3.444 | 3.45 | 3.456 | 0.012ø | 0.000211667 | 186 | 12 mmø
937704 | 1.64621 | 0.012 | 1.78985 | 0.00011308 | 0.0674759 |  | 3.43606 | 1.64621 | 1.64621 | 1.64621 | 3.43606 | 3.43606 | 3.43606 | 0.012ø | 0.000211667 | 186 | 12 mmø
937730 | 3.444 | 0.012 | 0.491543 | 0.00011308 | 0.0185307 | 0 | 3.45 | 3.45 | 3.456 | 3.45 | 3.444 | 3.45 | 3.456 | 0.012ø | 0.000211667 | 190 | 12 mmø
937732 | 1.64621 | 0.012 | 1.78985 | 0.00011308 | 0.0674759 |  | 3.43606 | 1.64621 | 1.64621 | 1.64621 | 3.43606 | 3.43606 | 3.43606 | 0.012ø | 0.000211667 | 190 | 12 mmø
937776 | 3.444 | 0.012 | 1.29955 | 0.00011308 | 0.048992 | 0 | 3.45 | 3.45 | 3.456 | 3.45 | 3.444 | 3.45 | 3.456 | 0.012ø | 0.000211667 | 22 | 12 mmø
937896 | 3.444 | 0.012 | 1.03943 | 0.00011308 | 0.0391854 | 0 | 3.45 | 3.45 | 3.456 | 3.45 | 3.444 | 3.45 | 3.456 | 0.012ø | 0.000211667 | 15 | 12 mmø
937904 | 3.444 | 0.012 | 1.05943 | 0.00011308 | 0.0399394 | 0 | 3.45 | 3.45 | 3.456 | 3.45 | 3.444 | 3.45 | 3.456 | 0.012ø | 0.000211667 | 185 | 12 mmø
937920 | 3.444 | 0.012 | 1.40616 | 0.00011308 | 0.0530112 | 0 | 3.45 | 3.45 | 3.456 | 3.45 | 3.444 | 3.45 | 3.456 | 0.012ø | 0.000211667 | 189 | 12 mmø
937938 | 3.444 | 0.012 | 0.556556 | 0.00011308 | 0.0209817 | 0 | 3.45 | 3.45 | 3.456 | 3.45 | 3.444 | 3.45 | 3.456 | 0.012ø | 0.000211667 | 192 | 12 mmø
937940 | 1.64621 | 0.012 | 1.78985 | 0.00011308 | 0.0674759 |  | 3.43606 | 1.64621 | 1.64621 | 1.64621 | 3.43606 | 3.43606 | 3.43606 | 0.012ø | 0.000211667 | 192 | 12 mmø
937987 | 3.444 | 0.012 | 0.556556 | 0.00011308 | 0.0209817 | 0 | 3.45 | 3.45 | 3.456 | 3.45 | 3.444 | 3.45 | 3.456 | 0.012ø | 0.000211667 | 193 | 12 mmø
937989 | 1.64621 | 0.012 | 1.78985 | 0.00011308 | 0.0674759 |  | 3.43606 | 1.64621 | 1.64621 | 1.64621 | 3.43606 | 3.43606 | 3.43606 | 0.012ø | 0.000211667 | 193 | 12 mmø
938011 | 3.444 | 0.012 | 0.562906 | 0.00011308 | 0.0212211 | 0 | 3.45 | 3.45 | 3.456 | 3.45 | 3.444 | 3.45 | 3.456 | 0.012ø | 0.000211667 | 34 | 12 mmø
938013 | 1.64621 | 0.012 | 1.78985 | 0.00011308 | 0.0674759 |  | 3.43606 | 1.64621 | 1.64621 | 1.64621 | 3.43606 | 3.43606 | 3.43606 | 0.012ø | 0.000211667 | 34 | 12 mmø
938062 | 3.444 | 0.012 | 1.29652 | 0.00011308 | 0.0488778 | 0 | 3.45 | 3.45 | 3.456 | 3.45 | 3.444 | 3.45 | 3.456 | 0.012ø | 0.000211667 | 194 | 12 mmø
938070 | 3.444 | 0.012 | 1.76578 | 0.00011308 | 0.0665681 | 0 | 3.45 | 3.45 | 3.456 | 3.45 | 3.444 | 3.45 | 3.456 | 0.012ø | 0.000211667 | 34 | 12 mmø
938106 | 3.444 | 0.012 | 5.79339 | 0.00011308 | 0.218406 | 0 | 3.45 | 3.45 | 3.456 | 3.45 | 3.444 | 3.45 | 3.456 | 0.012ø | 0.000211667 | 197 | 12 mmø
938108 | 1.64621 | 0.012 | 1.78985 | 0.00011308 | 0.0674759 |  | 3.43606 | 1.64621 | 1.64621 | 1.64621 | 3.43606 | 3.43606 | 3.43606 | 0.012ø | 0.000211667 | 197 | 12 mmø
938279 | 3.4405 | 0.019 | 0.329566 | 0.000283486 | 0.0196719 | 0 | 3.45 | 3.45 | 3.4595 | 3.45 | 3.4405 | 3.45 | 3.4595 | 0.019ø | 0.000133684 | 195 | 19 mmø
953222 | 2.4275 | 0.025 | 0.790423 | 0.0004908 | 0.0620796 | 0 | 2.44 | 2.44 | 2.4525 | 2.44 | 2.4275 | 2.44 | 2.4525 | 0.025ø | 0.0001016 | 207 | 25 mmø
953224 | 2.37387 | 0.025 | 0.403676 | 0.0004908 | 0.0317047 | 0 | 2.38637 | 2.38637 | 2.39887 | 2.38637 | 2.37387 | 2.38637 | 2.39887 | 0.025ø | 0.0001016 | 207 | 25 mmø
953226 | 2.40701 | 0.025 | 0.0123553 | 0.0004908 | 0.000970385 |  | 2.40701 | 2.40701 | 2.40701 | 2.41936 | 2.41936 | 2.41936 | 2.41936 | 0.025ø | 0.0001016 | 207 | 25 mmø
953245 | 2.40701 | 0.025 | 0.00600533 | 0.0004908 | 0.000471657 |  | 2.41301 | 2.40701 | 2.40701 | 2.40701 | 2.41301 | 2.41301 | 2.41301 | 0.025ø | 0.0001016 | 207 | 25 mmø
953254 | 2.4275 | 0.025 | 6.11837 | 0.0004908 | 0.480535 | 0 | 2.44 | 2.44 | 2.4525 | 2.44 | 2.4275 | 2.44 | 2.4525 | 0.025ø | 0.0001016 | 198 | 25 mmø
953291 | 2.4275 | 0.025 | 1.2198 | 0.0004908 | 0.0958029 | 0 | 2.44 | 2.44 | 2.4525 | 2.44 | 2.4275 | 2.44 | 2.4525 | 0.025ø | 0.0001016 | 226 | 25 mmø
953317 | 2.4275 | 0.025 | 0.658725 | 0.0004908 | 0.0517361 | 0 | 2.44 | 2.44 | 2.4525 | 2.44 | 2.4275 | 2.44 | 2.4525 | 0.025ø | 0.0001016 | 207 | 25 mmø
953358 | 0.7 | 0.025 | 1.71936 | 0.0004908 | 0.135038 |  | 0.7 | 0.7 | 0.7 | 2.41936 | 2.41936 | 2.41936 | 2.41936 | 0.025ø | 0.0001016 | 207 | 25 mmø
953451 | 2.4275 | 0.025 | 0.891897 | 0.0004908 | 0.0700495 | 0 | 2.44 | 2.44 | 2.4525 | 2.44 | 2.4275 | 2.44 | 2.4525 | 0.025ø | 0.0001016 | 198 | 25 mmø
953462 | 2.22699 | 0.025 | 0.192375 | 0.0004908 | 0.0151091 |  | 2.41936 | 2.22699 | 2.22699 | 2.22699 | 2.41936 | 2.41936 | 2.41936 | 0.025ø | 0.0001016 | 198 | 25 mmø
956450 | -1.50729 | 0.025 | 0.118771 | 0.0004908 | 0.00932829 | 0 | -1.49479 | -1.49479 | -1.48229 | -1.49478 | -1.50728 | -1.49478 | -1.48228 | 0.025ø | 0.0001016 | 226 | 25 mmø
956460 | -1.50729 | 0.025 | 0.188781 | 0.0004908 | 0.0148268 | 0 | -1.49479 | -1.49479 | -1.48229 | -1.49478 | -1.50728 | -1.49478 | -1.48228 | 0.025ø | 0.0001016 | 226 | 25 mmø
956683 | -1.50729 | 0.025 | 12.7814 | 0.0004908 | 1.00385 | 0 | -1.49479 | -1.49479 | -1.48229 | -1.49478 | -1.50728 | -1.49478 | -1.48228 | 0.025ø | 0.0001016 | 226 | 25 mmø
956834 | 3.7302 | 0.025 | 1.51027 | 0.0004908 | 0.118616 | 0 | 3.7427 | 3.7427 | 3.7552 | 3.74271 | 3.73021 | 3.74271 | 3.75521 | 0.025ø | 0.0001016 | 226 | 25 mmø
956960 | -1.47415 | 0.025 | 5.19621 | 0.0004908 | 0.40811 |  | 3.72207 | -1.47415 | -1.47415 | -1.47415 | 3.72207 | 3.72207 | 3.72207 | 0.025ø | 0.0001016 | 226 | 25 mmø
957162 | 3.47064 | 0.025 | 0.251431 | 0.0004908 | 0.0197473 |  | 3.72207 | 3.47064 | 3.47064 | 3.47064 | 3.72207 | 3.72207 | 3.72207 | 0.025ø | 0.0001016 | 226 | 25 mmø
957362 | -1.47414 | 0.025 | 1.04199 | 0.0004908 | 0.0818376 |  | -0.432155 | -1.47414 | -1.47414 | -1.47414 | -0.432155 | -0.432155 | -0.432154 | 0.025ø | 0.0001016 | 226 | 25 mmø

# IfcPump: _0033 - Pump, Dental Vacuum:_0033 - Pump, Dental Vacuum, _0033 - Pump, Dental Vacuum:_0033 - Pump, Dental Vacuum:947579
In: Nivel 1
Type - PredefinedType: CIRCULATOR; Material: <Unnamed>
Type - Other - Category: Mechanical Equipment; Family Name: _0033 - Pump, Dental Vacuum
Type - Constraints - Default Elevation: 0 m
Type - Identity Data - Type Name: _0033 - Pump, Dental Vacuum
Classification: D20 (FEMAP58)
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: _0033 - Pump, Dental Vacuum:_0033 - Pump, Dental Vacuum
Pset_EnvironmentalImpactIndicators - Reference: _0033 - Pump, Dental Vacuum:_0033 - Pump, Dental Vacuum
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 2.43728 m2; NetVolume: 0.0471176 m3
Other - Family: _0033 - Pump, Dental Vacuum; Family and Type: _0033 - Pump, Dental Vacuum: _0033 - Pump, Dental Vacuum; IfcType: _0033 - Pump, Dental Vacuum; Type: _0033 - Pump, Dental Vacuum; Type Id: 947629
Constraints - Level: Nivel 1; Moves With Nearby Elements: no; Elevation from Level: -0.4 m; Host: Level : Nivel 1; Offset from Host: -0.4 m
Dimensions - Area: 1.21864 m2; Volume: 0.0471176 m3
Identity Data - Mark: _0033-1
Phasing - Phase Created: Nueva construcción
AboveGround - AboveGround: yes

# IfcTank: A. O. Smith_Commerical Storage Tanks_TJV-200M:A. O. Smith_Commerical Storage Tanks_TJV-200M, A. O. Smith_Commerical Storage Tanks_TJV-200M:A. O. Smith_Commerical Storage Tanks_TJV-200M:947545
In: Nivel 1
Type - PredefinedType: STORAGE; Material: Metal Logo, Carbon Steel
Type - Other - Category: Mechanical Equipment; Family Name: A. O. Smith_Commerical Storage Tanks_TJV-200M
Type - Constraints - Default Elevation: 0 m; 3/4" Opening Vertical Offset: 0.127 m; Cold Water Connection Radius: 0.0254 m; Hot Water Connection Radius: 0.0254 m; Hot Water Inlet Connection Height: 3.28084 m; Hot Water Inlet Connection Offset: 0.127 m; Nominal Radius: 0.4064 m; Recirculation Inlet Height: 0.2794 m; Recirculation Water Inlet Connection Radius: 0.0254 m; T & P Opening Height: 1.6129 m; T & P Opening Radius: 0.0127 m
Type - Dimensions - Nominal Diameter: 0.8128 m; Nominal Height: 1.9558 m
Type - Identity Data - Assembly Code: D2020200; Assembly Description: Hot Water Service; CADworks URL: http://www.CADworks.net; Description: Commercial Jacketed and Insulated Storage Tank; Lining: Glass; Manufacturer: A. O. Smith; Model: TJV-200M; OmniClass: 23-65 20 11 17; Product data url: https://bimobject.com/aosmith/product/aosmith-tjvm; Product URL: http://www.hotwater.com/products/storage/st-jacketed.html; Type Name: A. O. Smith_Commerical Storage Tanks_TJV-200M; URL: http://www.hotwater.com
Type - Mechanical - Loads - Working Pressure: 1034214 Pa
Type - Plumbing - Cold Water Connection NPT: 0.0508 m; Hot Water Connection NPT: 0.0508 m; Recirculation Water Connection NPT: 0.0508 m; Volume: 0.662447 m3
Type - Structural - Shipping Weight (lbs): 560
Type - Pset_ManufacturerTypeInformation - Manufacturer: A. O. Smith
Classification: D2020200 Hot Water Service (Uniformat); D (FEMAP58); Group: Agua fría doméstica 1
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: A. O. Smith_Commerical Storage Tanks_TJV-200M:A. O. Smith_Commerical Storage Tanks_TJV-200M
Pset_EnvironmentalImpactIndicators - Reference: A. O. Smith_Commerical Storage Tanks_TJV-200M:A. O. Smith_Commerical Storage Tanks_TJV-200M
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 6.25331 m2; NetVolume: 1.0154 m3
Other - Family: A. O. Smith_Commerical Storage Tanks_TJV-200M; Family and Type: A. O. Smith_Commerical Storage Tanks_TJV-200M: A. O. Smith_Commerical Storage Tanks_TJV-200M; Type: A. O. Smith_Commerical Storage Tanks_TJV-200M; Type Id: 947516
Constraints - Level: Nivel 1; Schedule Level: Nivel 1; Elevation from Level: -0.05 m; Host: Orphaned
Dimensions - Area: 3.04912 m2; Volume: 1.01454 m3
Identity Data - Mark: 115
Mechanical - System Classification: Domestic Cold Water,Domestic Hot Water,Hydronic Return; System Name: Agua fría doméstica 1
Mechanical - Loads - Water Pressure Drop: 0 Pa
Phasing - Phase Created: Nueva construcción
Plumbing - Water Flow: 0 dm3/s
AboveGround - AboveGround: yes

# IfcTank: Tanque:Tanque (60)
In: Nivel 1
Type - PredefinedType: PRESSUREVESSEL; Material: <Unnamed>
Type - Other - Category: Mechanical Equipment; Family Name: Tanque
Type - Constraints - Default Elevation: 0 m
Type - Dimensions - ENTRADA: 0.032 m
Type - Identity Data - Type Name: Tanque
Classification: D (FEMAP58)
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: Tanque:Tanque
Pset_EnvironmentalImpactIndicators - Reference: Tanque:Tanque
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 2.49087 m2; NetVolume: 0.157259 m3
Other - Family: Tanque; Family and Type: Tanque: Tanque; Type: Tanque; Type Id: 939141
Constraints - Level: Nivel 1; Elevation from Level: -0.4 m; Host: Level : Nivel 1; Offset from Host: -0.4 m
Dimensions - ALTURA: 1.9 m; Area: 1.24543 m2; Volume: 0.157259 m3
Phasing - Phase Created: Nueva construcción
AboveGround - AboveGround: yes
Name (Tanque:Tanque:...) | Mark | System Classification
940090 | 43 | Hydronic Supply | Mechanical - System Name: Suministro hidrónico 1; Group: Suministro hidrónico 1
940091 | 44 | Hydronic Supply | Mechanical - System Name: Suministro hidrónico 1; Group: Suministro hidrónico 1
940115 | 57 | Hydronic Supply | Mechanical - System Name: Suministro hidrónico 3; Group: Suministro hidrónico 3
940116 | 58 | Hydronic Supply | Mechanical - System Name: Suministro hidrónico 3; Group: Suministro hidrónico 3
940126 | 59 | Undefined
940127 | 60 | Undefined
940128 | 61 | Undefined
940129 | 62 | Undefined
940130 | 63 | Undefined
940131 | 64 | Undefined
940132 | 65 | Undefined
940133 | 66 | Undefined
940134 | 67 | Undefined
940135 | 68 | Undefined
940136 | 69 | Undefined
940137 | 70 | Undefined
940138 | 71 | Undefined
940139 | 72 | Undefined
940147 | 73 | Undefined
940148 | 74 | Undefined
940149 | 75 | Undefined
940150 | 76 | Undefined
940151 | 77 | Undefined
940152 | 78 | Undefined
940153 | 79 | Undefined
940154 | 80 | Undefined
940155 | 81 | Undefined
940156 | 82 | Undefined
940157 | 83 | Undefined
940158 | 84 | Undefined
940159 | 85 | Undefined
940160 | 86 | Undefined
940176 | 87 | Undefined
940177 | 88 | Undefined
940178 | 89 | Undefined
940179 | 90 | Undefined
940271 | 91 | Hydronic Supply | Mechanical - System Name: Suministro hidrónico 1; Group: Suministro hidrónico 1
940272 | 92 | Hydronic Supply | Mechanical - System Name: Suministro hidrónico 1; Group: Suministro hidrónico 1
940273 | 93 | Hydronic Supply | Mechanical - System Name: Suministro hidrónico 3; Group: Suministro hidrónico 3
940274 | 94 | Hydronic Supply | Mechanical - System Name: Suministro hidrónico 3; Group: Suministro hidrónico 3
940308 | 95 | Hydronic Supply | Mechanical - System Name: Suministro hidrónico 1; Group: Suministro hidrónico 1
940309 | 96 | Hydronic Supply | Mechanical - System Name: Suministro hidrónico 1; Group: Suministro hidrónico 1
940310 | 97 | Hydronic Supply | Mechanical - System Name: Suministro hidrónico 3; Group: Suministro hidrónico 3
940311 | 98 | Hydronic Supply | Mechanical - System Name: Suministro hidrónico 3; Group: Suministro hidrónico 3
940352 | 99 | Hydronic Supply | Mechanical - System Name: Suministro hidrónico 1; Group: Suministro hidrónico 1
940353 | 100 | Hydronic Supply | Mechanical - System Name: Suministro hidrónico 1; Group: Suministro hidrónico 1
940354 | 101 | Hydronic Supply | Mechanical - System Name: Suministro hidrónico 3; Group: Suministro hidrónico 3
940355 | 102 | Hydronic Supply | Mechanical - System Name: Suministro hidrónico 3; Group: Suministro hidrónico 3
940389 | 103 | Hydronic Supply | Mechanical - System Name: Suministro hidrónico 1; Group: Suministro hidrónico 1
940390 | 104 | Hydronic Supply | Mechanical - System Name: Suministro hidrónico 1; Group: Suministro hidrónico 1
940391 | 105 | Hydronic Supply | Mechanical - System Name: Suministro hidrónico 3; Group: Suministro hidrónico 3
940392 | 106 | Hydronic Supply | Mechanical - System Name: Suministro hidrónico 3; Group: Suministro hidrónico 3
940426 | 107 | Hydronic Supply | Mechanical - System Name: Suministro hidrónico 1; Group: Suministro hidrónico 1
940427 | 108 | Hydronic Supply | Mechanical - System Name: Suministro hidrónico 1; Group: Suministro hidrónico 1
940428 | 109 | Hydronic Supply | Mechanical - System Name: Suministro hidrónico 3; Group: Suministro hidrónico 3
940429 | 110 | Hydronic Supply | Mechanical - System Name: Suministro hidrónico 3; Group: Suministro hidrónico 3
940463 | 111 | Hydronic Supply | Mechanical - System Name: Suministro hidrónico 1; Group: Suministro hidrónico 1
940464 | 112 | Hydronic Supply | Mechanical - System Name: Suministro hidrónico 1; Group: Suministro hidrónico 1
940465 | 113 | Hydronic Supply | Mechanical - System Name: Suministro hidrónico 3; Group: Suministro hidrónico 3
940466 | 114 | Hydronic Supply | Mechanical - System Name: Suministro hidrónico 3; Group: Suministro hidrónico 3

# IfcValve: Llave bola 70_300:1 Inch (4)
In: Nivel 1
Type - Material: Zinc - Apollo, Bronze - Apollo
Type - Other - Category: Pipe Accessories; Family Name: Llave bola 70_300
Type - Constraints - Default Elevation: 0 m
Type - Dimensions - Nominal Diameter: 0.0254 m
Type - Identity Data - Copyright: Copyright © 2013 Apollo Valves; Date Last Modified: May 7, 2013; Description: Single Union End Bronze Ball Valve 70-300 Series, 1 Inch; Equipment Abbreviation: PA; Family Version: 1.0.0; Manufacturer: Apollo Valves; Model: 70-305; Model Disclaimer: For More Information, Contact Apollo Valves; OmniClass Number: 23.65.55.14; OmniClass Title: Valves for Liquid Services; Original Creation Date: May 7, 2013; Product data url: https://bimobject.com/apollovalves/product/apollo-valves-110; Product Documentation Link: http://www.apollovalves.com/_products/70-300/SS_70-300_1055.pdf; Product Page URL: http://www.apollovalves.com/products/by_category; Provide Feedback: https://www.surveymonkey.com/s/6PWV7Y9; Type Name: 1 Inch; URL: http://www.apollovalves.com/
Type - Materials and Finishes - Product Material: Bronze - Apollo
Type - Mechanical - K Coefficient: 0
Type - Pset_ManufacturerTypeInformation - Manufacturer: Apollo Valves
Classification: D202 (FEMAP58)
Pset_EnvironmentalImpactIndicators - Reference: Llave bola 70_300:1 Inch; sets with these values: 2
Other - Family: Llave bola 70_300; Family and Type: Llave bola 70_300: 1 Inch; Type: 1 Inch; Type Id: 931598
Constraints - Level: Nivel 1
Construction - Configuration: Available; Handle Suffix: -01; Has Lever Extended Stem Handle: no; Has Lever Handle: yes; Has Round Extended Stem Handle: no; Has Round Handle: no; Has Tee Extended Stem Handle: no; Has Tee Handle: no; Has Thermoseal Handle: no
Dimensions - Maximum Size: 0.0254 m; Minimum Size: 0.0254 m; Size: 0.025ø-0.025ø; Volume: 0.000151792 m3
Graphics - Has Clearance Areas: no
Identity Data - Part Description: Single Union End Bronze Ball Valve 70-300 Series, 1 Inch; Part Number: 70-305
Mechanical - System Type: Suministro hidrónico; System Classification: Hydronic Supply
Phasing - Phase Created: Nueva construcción
Insulation - Insulation Thickness: 0 m; Overall Size: 25 mmø-25 mmø
AboveGround - AboveGround: yes
Name (Llave bola 70_300:1 Inch:...) | Elevation from Level (m) | Use Annotation Scale | Mark | System Name = Group
933007 | 1.73157 | yes | 12 | Suministro hidrónico 3
933076 | 1.6 | no | 13 | Suministro hidrónico 1
933752 | 1.72 | no | 14 | Suministro hidrónico 3
933793 | 1.6 | no | 15 | Suministro hidrónico 1

# IfcValve: M_Válvula de asiento - 10-50 mm - Con rosca:15 mm (6)
In: Nivel 1
Type - Material: <Unnamed>
Type - Other - Category: Pipe Accessories; Diámetro de bonete: 0.0158 m; Diámetro de tubería: 0.0158 m; Diámetro de vástago: 0.0112 m; Diámetro de volante de mano: 0.062 m; Diámetro nominal: 0.015 m; Family Name: M_Válvula de asiento - 10-50 mm - Con rosca; Media longitud de tubería: 0.03 m
Type - Constraints - Default Elevation: 0 m
Type - Dimensions - Altura de bonete: 0.013 m; Altura total: 0.095 m; Grosor de volante de mano: 0.0079 m; Longitud de tubería: 0.06 m; Radio de bonete: 0.0079 m; Radio de tubería: 0.0079 m; Radio de vástago: 0.0056 m; Radio de volante de mano: 0.031 m; Radio nominal: 0.0075 m
Type - Identity Data - OmniClass Number: 23.65.55.14.17; OmniClass Title: Adjusting/Controlling Valves for Liquid Services; Type Name: 15 mm
Type - Mechanical - K Coefficient: 14
Classification: D202 (FEMAP58); Group: Suministro hidrónico 4
Pset_EnvironmentalImpactIndicators - Reference: M_Válvula de asiento - 10-50 mm - Con rosca:15 mm; sets with these values: 2
Other - Family: M_Válvula de asiento - 10-50 mm - Con rosca; Family and Type: M_Válvula de asiento - 10-50 mm - Con rosca: 15 mm; Type: 15 mm; Type Id: 920274
Constraints - Level: Nivel 1
Dimensions - Maximum Size: 0.015 m; Minimum Size: 0.015 m; Size: 0.015ø-0.015ø; Volume: 0.0000348594 m3
Graphics - Use Annotation Scale: yes
Mechanical - System Type: Suministro hidrónico; System Classification: Hydronic Supply; System Name: Suministro hidrónico 4
Phasing - Phase Created: Nueva construcción
Insulation - Insulation Thickness: 0 m; Overall Size: 15 mmø-15 mmø
AboveGround - AboveGround: yes
Name (M_Válvula de asiento - 10-50 mm - Con rosca:15 mm:...) | Elevation from Level (m) | Mark
920355 | 4.36719 | 2
920456 | 4.36789 | 3
920644 | 4.39 | 4
920778 | 4.39 | 5
920953 | 4.37 | 7
954084 | 4.30541 | 16
